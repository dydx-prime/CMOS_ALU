v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 360 3750 490 3750 {lab=#net1}
N 360 3810 380 3810 {lab=gnd}
N 380 3780 380 3810 {lab=gnd}
N 360 3780 380 3780 {lab=gnd}
N 490 3810 510 3810 {lab=gnd}
N 510 3780 510 3810 {lab=gnd}
N 490 3780 510 3780 {lab=gnd}
N 430 3640 430 3650 {lab=#net2}
N 430 3650 430 3660 {lab=#net2}
N 430 3610 460 3610 {lab=Vdd}
N 460 3580 460 3610 {lab=Vdd}
N 430 3580 460 3580 {lab=Vdd}
N 430 3690 460 3690 {lab=Vdd}
N 460 3610 460 3690 {lab=Vdd}
N 430 3720 430 3750 {lab=#net1}
N 620 3670 640 3670 {lab=Vdd}
N 640 3670 640 3700 {lab=Vdd}
N 620 3700 640 3700 {lab=Vdd}
N 620 3760 640 3760 {lab=gnd}
N 640 3760 640 3790 {lab=gnd}
N 620 3790 640 3790 {lab=gnd}
N 570 3700 580 3700 {lab=#net1}
N 570 3700 570 3760 {lab=#net1}
N 570 3760 580 3760 {lab=#net1}
N 430 3730 570 3730 {lab=#net1}
N 360 4050 490 4050 {lab=#net3}
N 360 4110 380 4110 {lab=gnd}
N 380 4080 380 4110 {lab=gnd}
N 360 4080 380 4080 {lab=gnd}
N 490 4110 510 4110 {lab=gnd}
N 510 4080 510 4110 {lab=gnd}
N 490 4080 510 4080 {lab=gnd}
N 430 3940 430 3950 {lab=#net4}
N 430 3950 430 3960 {lab=#net4}
N 430 3910 460 3910 {lab=Vdd}
N 460 3880 460 3910 {lab=Vdd}
N 430 3880 460 3880 {lab=Vdd}
N 430 3990 460 3990 {lab=Vdd}
N 460 3910 460 3990 {lab=Vdd}
N 430 4020 430 4050 {lab=#net3}
N 620 3970 640 3970 {lab=Vdd}
N 640 3970 640 4000 {lab=Vdd}
N 620 4000 640 4000 {lab=Vdd}
N 620 4060 640 4060 {lab=gnd}
N 640 4060 640 4090 {lab=gnd}
N 620 4090 640 4090 {lab=gnd}
N 570 4000 580 4000 {lab=#net3}
N 570 4000 570 4060 {lab=#net3}
N 570 4060 580 4060 {lab=#net3}
N 430 4030 570 4030 {lab=#net3}
N 360 4360 490 4360 {lab=#net5}
N 360 4420 380 4420 {lab=gnd}
N 380 4390 380 4420 {lab=gnd}
N 360 4390 380 4390 {lab=gnd}
N 490 4420 510 4420 {lab=gnd}
N 510 4390 510 4420 {lab=gnd}
N 490 4390 510 4390 {lab=gnd}
N 430 4250 430 4260 {lab=#net6}
N 430 4260 430 4270 {lab=#net6}
N 430 4220 460 4220 {lab=Vdd}
N 460 4190 460 4220 {lab=Vdd}
N 430 4190 460 4190 {lab=Vdd}
N 430 4300 460 4300 {lab=Vdd}
N 460 4220 460 4300 {lab=Vdd}
N 430 4330 430 4360 {lab=#net5}
N 620 4280 640 4280 {lab=Vdd}
N 640 4280 640 4310 {lab=Vdd}
N 620 4310 640 4310 {lab=Vdd}
N 620 4370 640 4370 {lab=gnd}
N 640 4370 640 4400 {lab=gnd}
N 620 4400 640 4400 {lab=gnd}
N 570 4310 580 4310 {lab=#net5}
N 570 4310 570 4370 {lab=#net5}
N 570 4370 580 4370 {lab=#net5}
N 430 4340 570 4340 {lab=#net5}
N 360 4640 490 4640 {lab=#net7}
N 360 4700 380 4700 {lab=gnd}
N 380 4670 380 4700 {lab=gnd}
N 360 4670 380 4670 {lab=gnd}
N 490 4700 510 4700 {lab=gnd}
N 510 4670 510 4700 {lab=gnd}
N 490 4670 510 4670 {lab=gnd}
N 430 4530 430 4540 {lab=#net8}
N 430 4540 430 4550 {lab=#net8}
N 430 4500 460 4500 {lab=Vdd}
N 460 4470 460 4500 {lab=Vdd}
N 430 4470 460 4470 {lab=Vdd}
N 430 4580 460 4580 {lab=Vdd}
N 460 4500 460 4580 {lab=Vdd}
N 430 4610 430 4640 {lab=#net7}
N 620 4560 640 4560 {lab=Vdd}
N 640 4560 640 4590 {lab=Vdd}
N 620 4590 640 4590 {lab=Vdd}
N 620 4650 640 4650 {lab=gnd}
N 640 4650 640 4680 {lab=gnd}
N 620 4680 640 4680 {lab=gnd}
N 570 4590 580 4590 {lab=#net7}
N 570 4590 570 4650 {lab=#net7}
N 570 4650 580 4650 {lab=#net7}
N 430 4620 570 4620 {lab=#net7}
N 400 2220 400 2240 {lab=#net9}
N 400 2270 440 2270 {lab=gnd}
N 440 2190 440 2270 {lab=gnd}
N 400 2190 440 2190 {lab=gnd}
N 400 2140 400 2160 {lab=#net10}
N 320 2100 320 2120 {lab=#net10}
N 320 2120 400 2120 {lab=#net10}
N 400 2120 400 2140 {lab=#net10}
N 400 2120 400 2140 {lab=#net10}
N 400 2120 490 2120 {lab=#net10}
N 490 2100 490 2120 {lab=#net10}
N 400 2140 510 2140 {lab=#net10}
N 320 2070 350 2070 {lab=Vdd}
N 510 2140 540 2140 {lab=#net10}
N 540 2100 540 2140 {lab=#net10}
N 540 2100 580 2100 {lab=#net10}
N 540 2140 540 2190 {lab=#net10}
N 540 2190 580 2190 {lab=#net10}
N 620 2130 620 2160 {lab=AND0}
N 620 2190 640 2190 {lab=gnd}
N 620 2100 650 2100 {lab=Vdd}
N 650 2070 650 2100 {lab=Vdd}
N 350 2040 350 2070 {lab=Vdd}
N 320 2040 350 2040 {lab=Vdd}
N 620 2140 670 2140 {lab=AND0}
N 670 2140 680 2140 {lab=AND0}
N 490 2070 520 2070 {lab=Vdd}
N 620 2070 650 2070 {lab=Vdd}
N 490 2040 520 2040 {lab=Vdd}
N 520 2040 520 2070 {lab=Vdd}
N 620 2220 640 2220 {lab=gnd}
N 400 2300 440 2300 {lab=gnd}
N 440 2270 440 2300 {lab=gnd}
N 640 2190 640 2220 {lab=gnd}
N 350 2040 490 2040 {lab=Vdd}
N 520 2040 620 2040 {lab=Vdd}
N 620 2040 620 2070 {lab=Vdd}
N 390 2550 390 2570 {lab=#net11}
N 390 2600 430 2600 {lab=gnd}
N 430 2520 430 2600 {lab=gnd}
N 390 2520 430 2520 {lab=gnd}
N 390 2470 390 2490 {lab=#net12}
N 310 2430 310 2450 {lab=#net12}
N 310 2450 390 2450 {lab=#net12}
N 390 2450 390 2470 {lab=#net12}
N 390 2450 390 2470 {lab=#net12}
N 390 2450 480 2450 {lab=#net12}
N 480 2430 480 2450 {lab=#net12}
N 390 2470 500 2470 {lab=#net12}
N 310 2400 340 2400 {lab=Vdd}
N 500 2470 530 2470 {lab=#net12}
N 530 2430 530 2470 {lab=#net12}
N 530 2430 570 2430 {lab=#net12}
N 530 2470 530 2520 {lab=#net12}
N 530 2520 570 2520 {lab=#net12}
N 610 2460 610 2490 {lab=AND1}
N 610 2520 630 2520 {lab=gnd}
N 610 2430 640 2430 {lab=Vdd}
N 640 2400 640 2430 {lab=Vdd}
N 340 2370 340 2400 {lab=Vdd}
N 310 2370 340 2370 {lab=Vdd}
N 610 2470 660 2470 {lab=AND1}
N 480 2400 510 2400 {lab=Vdd}
N 610 2400 640 2400 {lab=Vdd}
N 480 2370 510 2370 {lab=Vdd}
N 510 2370 510 2400 {lab=Vdd}
N 610 2550 630 2550 {lab=gnd}
N 390 2630 430 2630 {lab=gnd}
N 430 2600 430 2630 {lab=gnd}
N 630 2520 630 2550 {lab=gnd}
N 340 2370 480 2370 {lab=Vdd}
N 510 2370 610 2370 {lab=Vdd}
N 610 2370 610 2400 {lab=Vdd}
N 390 2890 390 2910 {lab=#net13}
N 390 2940 430 2940 {lab=gnd}
N 430 2860 430 2940 {lab=gnd}
N 390 2860 430 2860 {lab=gnd}
N 390 2810 390 2830 {lab=#net14}
N 310 2770 310 2790 {lab=#net14}
N 310 2790 390 2790 {lab=#net14}
N 390 2790 390 2810 {lab=#net14}
N 390 2790 390 2810 {lab=#net14}
N 390 2790 480 2790 {lab=#net14}
N 480 2770 480 2790 {lab=#net14}
N 390 2810 500 2810 {lab=#net14}
N 310 2740 340 2740 {lab=Vdd}
N 500 2810 530 2810 {lab=#net14}
N 530 2770 530 2810 {lab=#net14}
N 530 2770 570 2770 {lab=#net14}
N 530 2810 530 2860 {lab=#net14}
N 530 2860 570 2860 {lab=#net14}
N 610 2800 610 2830 {lab=AND2}
N 610 2860 630 2860 {lab=gnd}
N 610 2770 640 2770 {lab=Vdd}
N 640 2740 640 2770 {lab=Vdd}
N 340 2710 340 2740 {lab=Vdd}
N 310 2710 340 2710 {lab=Vdd}
N 610 2810 660 2810 {lab=AND2}
N 660 2810 670 2810 {lab=AND2}
N 480 2740 510 2740 {lab=Vdd}
N 610 2740 640 2740 {lab=Vdd}
N 480 2710 510 2710 {lab=Vdd}
N 510 2710 510 2740 {lab=Vdd}
N 610 2890 630 2890 {lab=gnd}
N 390 2970 430 2970 {lab=gnd}
N 430 2940 430 2970 {lab=gnd}
N 630 2860 630 2890 {lab=gnd}
N 340 2710 480 2710 {lab=Vdd}
N 510 2710 610 2710 {lab=Vdd}
N 610 2710 610 2740 {lab=Vdd}
N 380 3230 380 3250 {lab=#net15}
N 380 3280 420 3280 {lab=gnd}
N 420 3200 420 3280 {lab=gnd}
N 380 3200 420 3200 {lab=gnd}
N 380 3150 380 3170 {lab=#net16}
N 300 3110 300 3130 {lab=#net16}
N 300 3130 380 3130 {lab=#net16}
N 380 3130 380 3150 {lab=#net16}
N 380 3130 380 3150 {lab=#net16}
N 380 3130 470 3130 {lab=#net16}
N 470 3110 470 3130 {lab=#net16}
N 380 3150 490 3150 {lab=#net16}
N 300 3080 330 3080 {lab=Vdd}
N 490 3150 520 3150 {lab=#net16}
N 520 3110 520 3150 {lab=#net16}
N 520 3110 560 3110 {lab=#net16}
N 520 3150 520 3200 {lab=#net16}
N 520 3200 560 3200 {lab=#net16}
N 600 3140 600 3170 {lab=AND3}
N 600 3200 620 3200 {lab=gnd}
N 600 3110 630 3110 {lab=Vdd}
N 630 3080 630 3110 {lab=Vdd}
N 330 3050 330 3080 {lab=Vdd}
N 300 3050 330 3050 {lab=Vdd}
N 600 3150 650 3150 {lab=AND3}
N 650 3150 660 3150 {lab=AND3}
N 470 3080 500 3080 {lab=Vdd}
N 600 3080 630 3080 {lab=Vdd}
N 470 3050 500 3050 {lab=Vdd}
N 500 3050 500 3080 {lab=Vdd}
N 600 3230 620 3230 {lab=gnd}
N 380 3310 420 3310 {lab=gnd}
N 420 3280 420 3310 {lab=gnd}
N 620 3200 620 3230 {lab=gnd}
N 330 3050 470 3050 {lab=Vdd}
N 500 3050 600 3050 {lab=Vdd}
N 600 3050 600 3080 {lab=Vdd}
N 380 740 510 740 {lab=NOR0}
N 450 680 450 740 {lab=NOR0}
N 450 700 570 700 {lab=NOR0}
N 380 800 400 800 {lab=gnd}
N 400 770 400 800 {lab=gnd}
N 380 770 400 770 {lab=gnd}
N 510 800 530 800 {lab=gnd}
N 530 770 530 800 {lab=gnd}
N 510 770 530 770 {lab=gnd}
N 450 600 450 610 {lab=#net17}
N 450 610 450 620 {lab=#net17}
N 450 650 480 650 {lab=Vdd}
N 480 540 480 650 {lab=Vdd}
N 450 540 480 540 {lab=Vdd}
N 380 1070 510 1070 {lab=NOR1}
N 450 1010 450 1070 {lab=NOR1}
N 450 1030 570 1030 {lab=NOR1}
N 380 1130 400 1130 {lab=gnd}
N 400 1100 400 1130 {lab=gnd}
N 380 1100 400 1100 {lab=gnd}
N 510 1130 530 1130 {lab=gnd}
N 530 1100 530 1130 {lab=gnd}
N 510 1100 530 1100 {lab=gnd}
N 450 930 450 940 {lab=#net18}
N 450 940 450 950 {lab=#net18}
N 450 980 480 980 {lab=Vdd}
N 480 870 480 980 {lab=Vdd}
N 450 870 480 870 {lab=Vdd}
N 390 1440 520 1440 {lab=NOR2}
N 460 1380 460 1440 {lab=NOR2}
N 460 1400 580 1400 {lab=NOR2}
N 390 1500 410 1500 {lab=gnd}
N 410 1470 410 1500 {lab=gnd}
N 390 1470 410 1470 {lab=gnd}
N 520 1500 540 1500 {lab=gnd}
N 540 1470 540 1500 {lab=gnd}
N 520 1470 540 1470 {lab=gnd}
N 460 1300 460 1310 {lab=#net19}
N 460 1310 460 1320 {lab=#net19}
N 460 1350 490 1350 {lab=Vdd}
N 490 1240 490 1350 {lab=Vdd}
N 460 1240 490 1240 {lab=Vdd}
N 390 1770 520 1770 {lab=NOR3}
N 460 1710 460 1770 {lab=NOR3}
N 460 1730 580 1730 {lab=NOR3}
N 390 1830 410 1830 {lab=gnd}
N 410 1800 410 1830 {lab=gnd}
N 390 1800 410 1800 {lab=gnd}
N 520 1830 540 1830 {lab=gnd}
N 540 1800 540 1830 {lab=gnd}
N 520 1800 540 1800 {lab=gnd}
N 460 1630 460 1640 {lab=#net20}
N 460 1640 460 1650 {lab=#net20}
N 460 1680 490 1680 {lab=Vdd}
N 490 1570 490 1680 {lab=Vdd}
N 460 1570 490 1570 {lab=Vdd}
N 480 -1040 480 -1020 {lab=#net21}
N 480 -990 520 -990 {lab=gnd}
N 520 -1070 520 -990 {lab=gnd}
N 480 -1070 520 -1070 {lab=gnd}
N 480 -1120 480 -1100 {lab=NAND0}
N 400 -1160 400 -1140 {lab=NAND0}
N 400 -1140 480 -1140 {lab=NAND0}
N 480 -1140 480 -1120 {lab=NAND0}
N 480 -1140 570 -1140 {lab=NAND0}
N 570 -1160 570 -1140 {lab=NAND0}
N 400 -1190 430 -1190 {lab=Vdd}
N 430 -1220 430 -1190 {lab=Vdd}
N 400 -1220 430 -1220 {lab=Vdd}
N 570 -1190 600 -1190 {lab=Vdd}
N 570 -1220 600 -1220 {lab=Vdd}
N 600 -1220 600 -1190 {lab=Vdd}
N 480 -960 520 -960 {lab=gnd}
N 520 -990 520 -960 {lab=gnd}
N 400 -1250 400 -1220 {lab=Vdd}
N 570 -1250 570 -1220 {lab=Vdd}
N 480 -960 480 -940 {lab=gnd}
N 400 -1250 570 -1250 {lab=Vdd}
N 480 -1120 520 -1120 {lab=NAND0}
N 470 -620 470 -600 {lab=#net22}
N 470 -570 510 -570 {lab=gnd}
N 510 -650 510 -570 {lab=gnd}
N 470 -650 510 -650 {lab=gnd}
N 470 -700 470 -680 {lab=NAND1}
N 390 -740 390 -720 {lab=NAND1}
N 390 -720 470 -720 {lab=NAND1}
N 470 -720 470 -700 {lab=NAND1}
N 470 -720 560 -720 {lab=NAND1}
N 560 -740 560 -720 {lab=NAND1}
N 390 -770 420 -770 {lab=Vdd}
N 420 -800 420 -770 {lab=Vdd}
N 390 -800 420 -800 {lab=Vdd}
N 560 -770 590 -770 {lab=Vdd}
N 560 -800 590 -800 {lab=Vdd}
N 590 -800 590 -770 {lab=Vdd}
N 470 -540 510 -540 {lab=gnd}
N 510 -570 510 -540 {lab=gnd}
N 390 -830 390 -800 {lab=Vdd}
N 560 -830 560 -800 {lab=Vdd}
N 470 -540 470 -520 {lab=gnd}
N 390 -830 560 -830 {lab=Vdd}
N 470 -700 510 -700 {lab=NAND1}
N 470 -220 470 -200 {lab=#net23}
N 470 -170 510 -170 {lab=gnd}
N 510 -250 510 -170 {lab=gnd}
N 470 -250 510 -250 {lab=gnd}
N 470 -300 470 -280 {lab=NAND2}
N 390 -340 390 -320 {lab=NAND2}
N 390 -320 470 -320 {lab=NAND2}
N 470 -320 470 -300 {lab=NAND2}
N 470 -320 560 -320 {lab=NAND2}
N 560 -340 560 -320 {lab=NAND2}
N 390 -370 420 -370 {lab=Vdd}
N 420 -400 420 -370 {lab=Vdd}
N 390 -400 420 -400 {lab=Vdd}
N 560 -370 590 -370 {lab=Vdd}
N 560 -400 590 -400 {lab=Vdd}
N 590 -400 590 -370 {lab=Vdd}
N 470 -140 510 -140 {lab=gnd}
N 510 -170 510 -140 {lab=gnd}
N 390 -430 390 -400 {lab=Vdd}
N 560 -430 560 -400 {lab=Vdd}
N 470 -140 470 -120 {lab=gnd}
N 390 -430 560 -430 {lab=Vdd}
N 470 -300 510 -300 {lab=NAND2}
N 460 180 460 200 {lab=#net24}
N 460 230 500 230 {lab=gnd}
N 500 150 500 230 {lab=gnd}
N 460 150 500 150 {lab=gnd}
N 460 100 460 120 {lab=NAND3}
N 380 60 380 80 {lab=NAND3}
N 380 80 460 80 {lab=NAND3}
N 460 80 460 100 {lab=NAND3}
N 460 80 550 80 {lab=NAND3}
N 550 60 550 80 {lab=NAND3}
N 380 30 410 30 {lab=Vdd}
N 410 0 410 30 {lab=Vdd}
N 380 0 410 0 {lab=Vdd}
N 550 30 580 30 {lab=Vdd}
N 550 0 580 0 {lab=Vdd}
N 580 0 580 30 {lab=Vdd}
N 460 260 500 260 {lab=gnd}
N 500 230 500 260 {lab=gnd}
N 380 -30 380 0 {lab=Vdd}
N 550 -30 550 0 {lab=Vdd}
N 460 260 460 280 {lab=gnd}
N 380 -30 550 -30 {lab=Vdd}
N 460 100 500 100 {lab=NAND3}
N 520 -1120 1050 -1120 {lab=NAND0}
N 510 -700 1040 -700 {lab=NAND1}
N 510 -300 1040 -300 {lab=NAND2}
N 500 100 1030 100 {lab=NAND3}
N 570 700 1010 700 {lab=NOR0}
N 570 1030 1010 1030 {lab=NOR1}
N 580 1400 1020 1400 {lab=NOR2}
N 580 1730 1020 1730 {lab=NOR3}
N 680 2140 1050 2140 {lab=AND0}
N 660 2470 1030 2470 {lab=AND1}
N 670 2810 1040 2810 {lab=AND2}
N 660 3150 1030 3150 {lab=AND3}
N 450 570 480 570 {lab=Vdd}
N 450 900 480 900 {lab=Vdd}
N 460 1270 490 1270 {lab=Vdd}
N 460 1600 490 1600 {lab=Vdd}
N 2180 3540 2200 3540 {lab=Vdd}
N 2200 3540 2200 3570 {lab=Vdd}
N 2180 3570 2200 3570 {lab=Vdd}
N 2180 3670 2200 3670 {lab=gnd}
N 2200 3670 2200 3700 {lab=gnd}
N 2180 3700 2200 3700 {lab=gnd}
N 2130 3570 2140 3570 {lab=S0_6}
N 2130 3570 2130 3630 {lab=S0_6}
N 2280 3550 2280 3600 {lab=#net25}
N 2280 3600 2280 3660 {lab=#net25}
N 2080 3330 2180 3330 {lab=S0_6}
N 2310 3440 2400 3440 {lab=#net26}
N 2320 3840 2400 3840 {lab=#net26}
N 2400 3440 2400 3840 {lab=#net26}
N 2910 3710 2910 3850 {lab=#net26}
N 2910 3850 2920 3850 {lab=#net26}
N 2980 3710 2980 3840 {lab=#net27}
N 2970 3710 2980 3710 {lab=#net27}
N 2850 3670 2940 3670 {lab=S1_3}
N 2850 3880 2870 3880 {lab=Vdd}
N 2870 3880 2870 3910 {lab=Vdd}
N 2850 3910 2870 3910 {lab=Vdd}
N 2870 3990 2870 4020 {lab=gnd}
N 2850 4020 2870 4020 {lab=gnd}
N 2800 3910 2810 3910 {lab=S1_3}
N 2800 3910 2800 3970 {lab=S1_3}
N 2950 3890 2950 3940 {lab=#net28}
N 2950 3940 2950 4000 {lab=#net28}
N 2920 4110 2920 4250 {lab=#net29}
N 2920 4250 2930 4250 {lab=#net29}
N 2990 4110 2990 4240 {lab=#net27}
N 2980 4110 2990 4110 {lab=#net27}
N 2870 4290 2960 4290 {lab=S1_3}
N 2950 4000 2950 4070 {lab=#net28}
N 2750 4290 2870 4290 {lab=S1_3}
N 2750 3670 2750 4290 {lab=S1_3}
N 2750 3670 2850 3670 {lab=S1_3}
N 2980 3780 3070 3780 {lab=#net27}
N 2990 4180 3070 4180 {lab=#net27}
N 3070 3780 3070 4180 {lab=#net27}
N 2500 3770 2910 3770 {lab=#net26}
N 2480 3650 2500 3770 {lab=#net26}
N 2400 3650 2480 3650 {lab=#net26}
N 3180 3970 3240 3970 {lab=#net30}
N 3120 3940 3140 3940 {lab=#net27}
N 3120 3940 3120 4000 {lab=#net27}
N 3120 4000 3140 4000 {lab=#net27}
N 3180 4030 3200 4030 {lab=gnd}
N 3180 4000 3200 4000 {lab=gnd}
N 3200 4000 3200 4030 {lab=gnd}
N 3180 3910 3200 3910 {lab=Vdd}
N 3200 3910 3200 3940 {lab=Vdd}
N 3180 3940 3200 3940 {lab=Vdd}
N 3240 3970 3300 3970 {lab=#net30}
N 3420 3970 3480 3970 {lab=F3}
N 3360 3940 3380 3940 {lab=#net30}
N 3360 3940 3360 4000 {lab=#net30}
N 3360 4000 3380 4000 {lab=#net30}
N 3420 4030 3440 4030 {lab=gnd}
N 3420 4000 3440 4000 {lab=gnd}
N 3440 4000 3440 4030 {lab=gnd}
N 3420 3910 3440 3910 {lab=Vdd}
N 3440 3910 3440 3940 {lab=Vdd}
N 3420 3940 3440 3940 {lab=Vdd}
N 3300 3970 3360 3970 {lab=#net30}
N 3480 3970 3540 3970 {lab=F3}
N 3070 3970 3120 3970 {lab=#net27}
N 2260 4040 2260 4180 {lab=AND3}
N 2260 4180 2270 4180 {lab=AND3}
N 2330 4040 2330 4170 {lab=#net29}
N 2320 4040 2330 4040 {lab=#net29}
N 2200 4000 2290 4000 {lab=S0_7}
N 2200 4210 2220 4210 {lab=Vdd}
N 2220 4210 2220 4240 {lab=Vdd}
N 2200 4240 2220 4240 {lab=Vdd}
N 2200 4320 2220 4320 {lab=gnd}
N 2220 4320 2220 4350 {lab=gnd}
N 2200 4350 2220 4350 {lab=gnd}
N 2150 4240 2160 4240 {lab=S0_7}
N 2150 4240 2150 4300 {lab=S0_7}
N 2300 4220 2300 4270 {lab=#net31}
N 2300 4270 2300 4330 {lab=#net31}
N 2270 4440 2270 4580 {lab=OR3}
N 2270 4580 2280 4580 {lab=OR3}
N 2340 4440 2340 4570 {lab=#net29}
N 2330 4440 2340 4440 {lab=#net29}
N 2220 4620 2310 4620 {lab=S0_7}
N 2300 4330 2300 4400 {lab=#net31}
N 2100 4620 2220 4620 {lab=S0_7}
N 2100 4000 2100 4620 {lab=S0_7}
N 2100 4000 2200 4000 {lab=S0_7}
N 2330 4110 2420 4110 {lab=#net29}
N 2340 4510 2420 4510 {lab=#net29}
N 2420 4110 2420 4510 {lab=#net29}
N 2520 4180 2920 4180 {lab=#net29}
N 2520 4180 2520 4360 {lab=#net29}
N 2420 4360 2520 4360 {lab=#net29}
N 2330 4170 2330 4180 {lab=#net29}
N 2340 4570 2340 4580 {lab=#net29}
N 2990 4240 2990 4250 {lab=#net27}
N 2980 3840 2980 3850 {lab=#net27}
N 2250 3730 2250 3770 {lab=NOR3}
N 2250 3770 2250 3870 {lab=NOR3}
N 2310 3730 2310 3870 {lab=#net26}
N 2310 3800 2320 3800 {lab=#net26}
N 2320 3800 2320 3840 {lab=#net26}
N 2280 3770 2330 3770 {lab=#net25}
N 2330 3660 2330 3770 {lab=#net25}
N 2280 3660 2330 3660 {lab=#net25}
N 2080 3830 2280 3830 {lab=S0_6}
N 2080 3550 2080 3830 {lab=S0_6}
N 2080 3330 2080 3550 {lab=S0_6}
N 2290 3350 2290 3470 {lab=#net26}
N 2230 3350 2230 3470 {lab=NAND3}
N 2210 3390 2260 3390 {lab=S0_6}
N 2210 3330 2210 3390 {lab=S0_6}
N 2180 3330 2210 3330 {lab=S0_6}
N 2200 3430 2260 3430 {lab=#net25}
N 2200 3430 2200 3510 {lab=#net25}
N 2200 3510 2280 3510 {lab=#net25}
N 2280 3510 2280 3550 {lab=#net25}
N 2290 3410 2310 3410 {lab=#net26}
N 2310 3410 2310 3440 {lab=#net26}
N 2100 4270 2150 4270 {lab=S0_7}
N 2080 3600 2130 3600 {lab=S0_6}
N 2750 3940 2800 3940 {lab=S1_3}
N 2150 4320 2160 4320 {lab=S0_7}
N 2150 4300 2150 4320 {lab=S0_7}
N 2200 4270 2200 4290 {lab=#net31}
N 2180 3600 2180 3640 {lab=#net25}
N 2180 3620 2280 3620 {lab=#net25}
N 2130 3630 2130 3670 {lab=S0_6}
N 2130 3670 2140 3670 {lab=S0_6}
N 2800 3970 2800 3990 {lab=S1_3}
N 2800 3990 2810 3990 {lab=S1_3}
N 2850 3940 2850 3960 {lab=#net28}
N 2850 3950 2950 3950 {lab=#net28}
N 2200 4280 2300 4280 {lab=#net31}
N 2850 3990 2870 3990 {lab=gnd}
N 2160 2090 2180 2090 {lab=Vdd}
N 2180 2090 2180 2120 {lab=Vdd}
N 2160 2120 2180 2120 {lab=Vdd}
N 2160 2220 2180 2220 {lab=gnd}
N 2180 2220 2180 2250 {lab=gnd}
N 2160 2250 2180 2250 {lab=gnd}
N 2110 2120 2120 2120 {lab=S0_4}
N 2110 2120 2110 2180 {lab=S0_4}
N 2260 2100 2260 2150 {lab=#net32}
N 2260 2150 2260 2210 {lab=#net32}
N 2060 1880 2160 1880 {lab=S0_4}
N 2290 1990 2380 1990 {lab=#net33}
N 2300 2390 2380 2390 {lab=#net33}
N 2380 1990 2380 2390 {lab=#net33}
N 2890 2260 2890 2400 {lab=#net33}
N 2890 2400 2900 2400 {lab=#net33}
N 2960 2260 2960 2390 {lab=#net34}
N 2950 2260 2960 2260 {lab=#net34}
N 2830 2220 2920 2220 {lab=S1_2}
N 2830 2430 2850 2430 {lab=Vdd}
N 2850 2430 2850 2460 {lab=Vdd}
N 2830 2460 2850 2460 {lab=Vdd}
N 2850 2540 2850 2570 {lab=gnd}
N 2830 2570 2850 2570 {lab=gnd}
N 2780 2460 2790 2460 {lab=S1_2}
N 2780 2460 2780 2520 {lab=S1_2}
N 2930 2440 2930 2490 {lab=#net35}
N 2930 2490 2930 2550 {lab=#net35}
N 2900 2660 2900 2800 {lab=#net36}
N 2900 2800 2910 2800 {lab=#net36}
N 2970 2660 2970 2790 {lab=#net34}
N 2960 2660 2970 2660 {lab=#net34}
N 2850 2840 2940 2840 {lab=S1_2}
N 2930 2550 2930 2620 {lab=#net35}
N 2730 2840 2850 2840 {lab=S1_2}
N 2730 2220 2730 2840 {lab=S1_2}
N 2730 2220 2830 2220 {lab=S1_2}
N 2960 2330 3050 2330 {lab=#net34}
N 2970 2730 3050 2730 {lab=#net34}
N 3050 2330 3050 2730 {lab=#net34}
N 2480 2320 2890 2320 {lab=#net33}
N 2460 2200 2480 2320 {lab=#net33}
N 2380 2200 2460 2200 {lab=#net33}
N 3160 2520 3220 2520 {lab=#net37}
N 3100 2490 3120 2490 {lab=#net34}
N 3100 2490 3100 2550 {lab=#net34}
N 3100 2550 3120 2550 {lab=#net34}
N 3160 2580 3180 2580 {lab=gnd}
N 3160 2550 3180 2550 {lab=gnd}
N 3180 2550 3180 2580 {lab=gnd}
N 3160 2460 3180 2460 {lab=Vdd}
N 3180 2460 3180 2490 {lab=Vdd}
N 3160 2490 3180 2490 {lab=Vdd}
N 3220 2520 3280 2520 {lab=#net37}
N 3400 2520 3460 2520 {lab=F2}
N 3340 2490 3360 2490 {lab=#net37}
N 3340 2490 3340 2550 {lab=#net37}
N 3340 2550 3360 2550 {lab=#net37}
N 3400 2580 3420 2580 {lab=gnd}
N 3400 2550 3420 2550 {lab=gnd}
N 3420 2550 3420 2580 {lab=gnd}
N 3400 2460 3420 2460 {lab=Vdd}
N 3420 2460 3420 2490 {lab=Vdd}
N 3400 2490 3420 2490 {lab=Vdd}
N 3280 2520 3340 2520 {lab=#net37}
N 3460 2520 3520 2520 {lab=F2}
N 3050 2520 3100 2520 {lab=#net34}
N 2240 2590 2240 2730 {lab=AND2}
N 2240 2730 2250 2730 {lab=AND2}
N 2310 2590 2310 2720 {lab=#net36}
N 2300 2590 2310 2590 {lab=#net36}
N 2180 2550 2270 2550 {lab=S0_5}
N 2180 2760 2200 2760 {lab=Vdd}
N 2200 2760 2200 2790 {lab=Vdd}
N 2180 2790 2200 2790 {lab=Vdd}
N 2180 2870 2200 2870 {lab=gnd}
N 2200 2870 2200 2900 {lab=gnd}
N 2180 2900 2200 2900 {lab=gnd}
N 2130 2790 2140 2790 {lab=S0_5}
N 2130 2790 2130 2850 {lab=S0_5}
N 2280 2770 2280 2820 {lab=#net38}
N 2280 2820 2280 2880 {lab=#net38}
N 2250 2990 2250 3130 {lab=OR2}
N 2250 3130 2260 3130 {lab=OR2}
N 2320 2990 2320 3120 {lab=#net36}
N 2310 2990 2320 2990 {lab=#net36}
N 2200 3170 2290 3170 {lab=S0_5}
N 2280 2880 2280 2950 {lab=#net38}
N 2080 3170 2200 3170 {lab=S0_5}
N 2080 2550 2080 3170 {lab=S0_5}
N 2080 2550 2180 2550 {lab=S0_5}
N 2310 2660 2400 2660 {lab=#net36}
N 2320 3060 2400 3060 {lab=#net36}
N 2400 2660 2400 3060 {lab=#net36}
N 2500 2730 2900 2730 {lab=#net36}
N 2500 2730 2500 2910 {lab=#net36}
N 2400 2910 2500 2910 {lab=#net36}
N 2310 2720 2310 2730 {lab=#net36}
N 2320 3120 2320 3130 {lab=#net36}
N 2970 2790 2970 2800 {lab=#net34}
N 2960 2390 2960 2400 {lab=#net34}
N 2230 2280 2230 2320 {lab=NOR2}
N 2230 2320 2230 2420 {lab=NOR2}
N 2290 2280 2290 2420 {lab=#net33}
N 2290 2350 2300 2350 {lab=#net33}
N 2300 2350 2300 2390 {lab=#net33}
N 2260 2320 2310 2320 {lab=#net32}
N 2310 2210 2310 2320 {lab=#net32}
N 2260 2210 2310 2210 {lab=#net32}
N 2060 2380 2260 2380 {lab=S0_4}
N 2060 2100 2060 2380 {lab=S0_4}
N 2060 1880 2060 2100 {lab=S0_4}
N 2270 1900 2270 2020 {lab=#net33}
N 2210 1900 2210 2020 {lab=NAND2}
N 2190 1940 2240 1940 {lab=S0_4}
N 2190 1880 2190 1940 {lab=S0_4}
N 2160 1880 2190 1880 {lab=S0_4}
N 2180 1980 2240 1980 {lab=#net32}
N 2180 1980 2180 2060 {lab=#net32}
N 2180 2060 2260 2060 {lab=#net32}
N 2260 2060 2260 2100 {lab=#net32}
N 2270 1960 2290 1960 {lab=#net33}
N 2290 1960 2290 1990 {lab=#net33}
N 2080 2820 2130 2820 {lab=S0_5}
N 2060 2150 2110 2150 {lab=S0_4}
N 2730 2490 2780 2490 {lab=S1_2}
N 2130 2870 2140 2870 {lab=S0_5}
N 2130 2850 2130 2870 {lab=S0_5}
N 2180 2820 2180 2840 {lab=#net38}
N 2160 2150 2160 2190 {lab=#net32}
N 2160 2170 2260 2170 {lab=#net32}
N 2110 2180 2110 2220 {lab=S0_4}
N 2110 2220 2120 2220 {lab=S0_4}
N 2780 2520 2780 2540 {lab=S1_2}
N 2780 2540 2790 2540 {lab=S1_2}
N 2830 2490 2830 2510 {lab=#net35}
N 2830 2500 2930 2500 {lab=#net35}
N 2180 2830 2280 2830 {lab=#net38}
N 2830 2540 2850 2540 {lab=gnd}
N 2150 670 2170 670 {lab=Vdd}
N 2170 670 2170 700 {lab=Vdd}
N 2150 700 2170 700 {lab=Vdd}
N 2150 800 2170 800 {lab=gnd}
N 2170 800 2170 830 {lab=gnd}
N 2150 830 2170 830 {lab=gnd}
N 2100 700 2110 700 {lab=S0_2}
N 2100 700 2100 760 {lab=S0_2}
N 2250 680 2250 730 {lab=#net39}
N 2250 730 2250 790 {lab=#net39}
N 2050 460 2150 460 {lab=S0_2}
N 2280 570 2370 570 {lab=#net40}
N 2290 970 2370 970 {lab=#net40}
N 2370 570 2370 970 {lab=#net40}
N 2880 840 2880 980 {lab=#net40}
N 2880 980 2890 980 {lab=#net40}
N 2950 840 2950 970 {lab=#net41}
N 2940 840 2950 840 {lab=#net41}
N 2820 800 2910 800 {lab=S1_1}
N 2820 1010 2840 1010 {lab=Vdd}
N 2840 1010 2840 1040 {lab=Vdd}
N 2820 1040 2840 1040 {lab=Vdd}
N 2840 1120 2840 1150 {lab=gnd}
N 2820 1150 2840 1150 {lab=gnd}
N 2770 1040 2780 1040 {lab=S1_1}
N 2770 1040 2770 1100 {lab=S1_1}
N 2920 1020 2920 1070 {lab=#net42}
N 2920 1070 2920 1130 {lab=#net42}
N 2890 1240 2890 1380 {lab=#net43}
N 2890 1380 2900 1380 {lab=#net43}
N 2960 1240 2960 1370 {lab=#net41}
N 2950 1240 2960 1240 {lab=#net41}
N 2840 1420 2930 1420 {lab=S1_1}
N 2920 1130 2920 1200 {lab=#net42}
N 2720 1420 2840 1420 {lab=S1_1}
N 2720 800 2720 1420 {lab=S1_1}
N 2720 800 2820 800 {lab=S1_1}
N 2950 910 3040 910 {lab=#net41}
N 2960 1310 3040 1310 {lab=#net41}
N 3040 910 3040 1310 {lab=#net41}
N 2470 900 2880 900 {lab=#net40}
N 2450 780 2470 900 {lab=#net40}
N 2370 780 2450 780 {lab=#net40}
N 3150 1100 3210 1100 {lab=#net44}
N 3090 1070 3110 1070 {lab=#net41}
N 3090 1070 3090 1130 {lab=#net41}
N 3090 1130 3110 1130 {lab=#net41}
N 3150 1160 3170 1160 {lab=gnd}
N 3150 1130 3170 1130 {lab=gnd}
N 3170 1130 3170 1160 {lab=gnd}
N 3150 1040 3170 1040 {lab=Vdd}
N 3170 1040 3170 1070 {lab=Vdd}
N 3150 1070 3170 1070 {lab=Vdd}
N 3210 1100 3270 1100 {lab=#net44}
N 3390 1100 3450 1100 {lab=F1}
N 3330 1070 3350 1070 {lab=#net44}
N 3330 1070 3330 1130 {lab=#net44}
N 3330 1130 3350 1130 {lab=#net44}
N 3390 1160 3410 1160 {lab=gnd}
N 3390 1130 3410 1130 {lab=gnd}
N 3410 1130 3410 1160 {lab=gnd}
N 3390 1040 3410 1040 {lab=Vdd}
N 3410 1040 3410 1070 {lab=Vdd}
N 3390 1070 3410 1070 {lab=Vdd}
N 3270 1100 3330 1100 {lab=#net44}
N 3450 1100 3510 1100 {lab=F1}
N 3040 1100 3090 1100 {lab=#net41}
N 2230 1170 2230 1310 {lab=AND1}
N 2230 1310 2240 1310 {lab=AND1}
N 2300 1170 2300 1300 {lab=#net43}
N 2290 1170 2300 1170 {lab=#net43}
N 2170 1130 2260 1130 {lab=S0_3}
N 2170 1340 2190 1340 {lab=Vdd}
N 2190 1340 2190 1370 {lab=Vdd}
N 2170 1370 2190 1370 {lab=Vdd}
N 2170 1450 2190 1450 {lab=gnd}
N 2190 1450 2190 1480 {lab=gnd}
N 2170 1480 2190 1480 {lab=gnd}
N 2120 1370 2130 1370 {lab=S0_3}
N 2120 1370 2120 1430 {lab=S0_3}
N 2270 1350 2270 1400 {lab=#net45}
N 2270 1400 2270 1460 {lab=#net45}
N 2240 1570 2240 1710 {lab=OR1}
N 2240 1710 2250 1710 {lab=OR1}
N 2310 1570 2310 1700 {lab=#net43}
N 2300 1570 2310 1570 {lab=#net43}
N 2190 1750 2280 1750 {lab=S0_3}
N 2270 1460 2270 1530 {lab=#net45}
N 2070 1750 2190 1750 {lab=S0_3}
N 2070 1130 2070 1750 {lab=S0_3}
N 2070 1130 2170 1130 {lab=S0_3}
N 2300 1240 2390 1240 {lab=#net43}
N 2310 1640 2390 1640 {lab=#net43}
N 2390 1240 2390 1640 {lab=#net43}
N 2490 1310 2890 1310 {lab=#net43}
N 2490 1310 2490 1490 {lab=#net43}
N 2390 1490 2490 1490 {lab=#net43}
N 2300 1300 2300 1310 {lab=#net43}
N 2310 1700 2310 1710 {lab=#net43}
N 2960 1370 2960 1380 {lab=#net41}
N 2950 970 2950 980 {lab=#net41}
N 2220 860 2220 900 {lab=NOR1}
N 2220 900 2220 1000 {lab=NOR1}
N 2280 860 2280 1000 {lab=#net40}
N 2280 930 2290 930 {lab=#net40}
N 2290 930 2290 970 {lab=#net40}
N 2250 900 2300 900 {lab=#net39}
N 2300 790 2300 900 {lab=#net39}
N 2250 790 2300 790 {lab=#net39}
N 2050 960 2250 960 {lab=S0_2}
N 2050 680 2050 960 {lab=S0_2}
N 2050 460 2050 680 {lab=S0_2}
N 2260 480 2260 600 {lab=#net40}
N 2200 480 2200 600 {lab=NAND1}
N 2180 520 2230 520 {lab=S0_2}
N 2180 460 2180 520 {lab=S0_2}
N 2150 460 2180 460 {lab=S0_2}
N 2170 560 2230 560 {lab=#net39}
N 2170 560 2170 640 {lab=#net39}
N 2170 640 2250 640 {lab=#net39}
N 2250 640 2250 680 {lab=#net39}
N 2260 540 2280 540 {lab=#net40}
N 2280 540 2280 570 {lab=#net40}
N 2070 1400 2120 1400 {lab=S0_3}
N 2050 730 2100 730 {lab=S0_2}
N 2720 1070 2770 1070 {lab=S1_1}
N 2120 1450 2130 1450 {lab=S0_3}
N 2120 1430 2120 1450 {lab=S0_3}
N 2170 1400 2170 1420 {lab=#net45}
N 2150 730 2150 770 {lab=#net39}
N 2150 750 2250 750 {lab=#net39}
N 2100 760 2100 800 {lab=S0_2}
N 2100 800 2110 800 {lab=S0_2}
N 2770 1100 2770 1120 {lab=S1_1}
N 2770 1120 2780 1120 {lab=S1_1}
N 2820 1070 2820 1090 {lab=#net42}
N 2820 1080 2920 1080 {lab=#net42}
N 2170 1410 2270 1410 {lab=#net45}
N 2820 1120 2840 1120 {lab=gnd}
N 2120 -730 2140 -730 {lab=Vdd}
N 2140 -730 2140 -700 {lab=Vdd}
N 2120 -700 2140 -700 {lab=Vdd}
N 2120 -600 2140 -600 {lab=gnd}
N 2140 -600 2140 -570 {lab=gnd}
N 2120 -570 2140 -570 {lab=gnd}
N 2070 -700 2080 -700 {lab=S0_0}
N 2070 -700 2070 -640 {lab=S0_0}
N 2220 -720 2220 -670 {lab=#net46}
N 2220 -670 2220 -610 {lab=#net46}
N 2020 -940 2120 -940 {lab=S0_0}
N 2250 -830 2340 -830 {lab=#net47}
N 2260 -430 2340 -430 {lab=#net47}
N 2340 -830 2340 -430 {lab=#net47}
N 2850 -560 2850 -420 {lab=#net47}
N 2850 -420 2860 -420 {lab=#net47}
N 2920 -560 2920 -430 {lab=#net48}
N 2910 -560 2920 -560 {lab=#net48}
N 2790 -600 2880 -600 {lab=S1_0}
N 2790 -390 2810 -390 {lab=Vdd}
N 2810 -390 2810 -360 {lab=Vdd}
N 2790 -360 2810 -360 {lab=Vdd}
N 2810 -280 2810 -250 {lab=gnd}
N 2790 -250 2810 -250 {lab=gnd}
N 2740 -360 2750 -360 {lab=S1_0}
N 2740 -360 2740 -300 {lab=S1_0}
N 2890 -380 2890 -330 {lab=#net49}
N 2890 -330 2890 -270 {lab=#net49}
N 2860 -160 2860 -20 {lab=#net50}
N 2860 -20 2870 -20 {lab=#net50}
N 2930 -160 2930 -30 {lab=#net48}
N 2920 -160 2930 -160 {lab=#net48}
N 2810 20 2900 20 {lab=S1_0}
N 2890 -270 2890 -200 {lab=#net49}
N 2690 20 2810 20 {lab=S1_0}
N 2690 -600 2690 20 {lab=S1_0}
N 2690 -600 2790 -600 {lab=S1_0}
N 2920 -490 3010 -490 {lab=#net48}
N 2930 -90 3010 -90 {lab=#net48}
N 3010 -490 3010 -90 {lab=#net48}
N 2440 -500 2850 -500 {lab=#net47}
N 2420 -620 2440 -500 {lab=#net47}
N 2340 -620 2420 -620 {lab=#net47}
N 3120 -300 3180 -300 {lab=#net51}
N 3060 -330 3080 -330 {lab=#net48}
N 3060 -330 3060 -270 {lab=#net48}
N 3060 -270 3080 -270 {lab=#net48}
N 3120 -240 3140 -240 {lab=gnd}
N 3120 -270 3140 -270 {lab=gnd}
N 3140 -270 3140 -240 {lab=gnd}
N 3120 -360 3140 -360 {lab=Vdd}
N 3140 -360 3140 -330 {lab=Vdd}
N 3120 -330 3140 -330 {lab=Vdd}
N 3180 -300 3240 -300 {lab=#net51}
N 3360 -300 3420 -300 {lab=F0}
N 3300 -330 3320 -330 {lab=#net51}
N 3300 -330 3300 -270 {lab=#net51}
N 3300 -270 3320 -270 {lab=#net51}
N 3360 -240 3380 -240 {lab=gnd}
N 3360 -270 3380 -270 {lab=gnd}
N 3380 -270 3380 -240 {lab=gnd}
N 3360 -360 3380 -360 {lab=Vdd}
N 3380 -360 3380 -330 {lab=Vdd}
N 3360 -330 3380 -330 {lab=Vdd}
N 3240 -300 3300 -300 {lab=#net51}
N 3420 -300 3480 -300 {lab=F0}
N 3010 -300 3060 -300 {lab=#net48}
N 2200 -230 2200 -90 {lab=AND0}
N 2200 -90 2210 -90 {lab=AND0}
N 2270 -230 2270 -100 {lab=#net50}
N 2260 -230 2270 -230 {lab=#net50}
N 2140 -270 2230 -270 {lab=S0_1}
N 2140 -60 2160 -60 {lab=Vdd}
N 2160 -60 2160 -30 {lab=Vdd}
N 2140 -30 2160 -30 {lab=Vdd}
N 2140 50 2160 50 {lab=gnd}
N 2160 50 2160 80 {lab=gnd}
N 2140 80 2160 80 {lab=gnd}
N 2090 -30 2100 -30 {lab=S0_1}
N 2090 -30 2090 30 {lab=S0_1}
N 2240 -50 2240 0 {lab=#net52}
N 2240 0 2240 60 {lab=#net52}
N 2210 170 2210 310 {lab=OR0}
N 2210 310 2220 310 {lab=OR0}
N 2280 170 2280 300 {lab=#net50}
N 2270 170 2280 170 {lab=#net50}
N 2160 350 2250 350 {lab=S0_1}
N 2240 60 2240 130 {lab=#net52}
N 2040 350 2160 350 {lab=S0_1}
N 2040 -270 2040 350 {lab=S0_1}
N 2040 -270 2140 -270 {lab=S0_1}
N 2270 -160 2360 -160 {lab=#net50}
N 2280 240 2360 240 {lab=#net50}
N 2360 -160 2360 240 {lab=#net50}
N 2460 -90 2860 -90 {lab=#net50}
N 2460 -90 2460 90 {lab=#net50}
N 2360 90 2460 90 {lab=#net50}
N 2270 -100 2270 -90 {lab=#net50}
N 2280 300 2280 310 {lab=#net50}
N 2930 -30 2930 -20 {lab=#net48}
N 2920 -430 2920 -420 {lab=#net48}
N 2190 -540 2190 -500 {lab=NOR0}
N 2190 -500 2190 -400 {lab=NOR0}
N 2250 -540 2250 -400 {lab=#net47}
N 2250 -470 2260 -470 {lab=#net47}
N 2260 -470 2260 -430 {lab=#net47}
N 2220 -500 2270 -500 {lab=#net46}
N 2270 -610 2270 -500 {lab=#net46}
N 2220 -610 2270 -610 {lab=#net46}
N 2020 -440 2220 -440 {lab=S0_0}
N 2020 -720 2020 -440 {lab=S0_0}
N 2020 -940 2020 -720 {lab=S0_0}
N 2230 -920 2230 -800 {lab=#net47}
N 2170 -920 2170 -800 {lab=NAND0}
N 2150 -880 2200 -880 {lab=S0_0}
N 2150 -940 2150 -880 {lab=S0_0}
N 2120 -940 2150 -940 {lab=S0_0}
N 2140 -840 2200 -840 {lab=#net46}
N 2140 -840 2140 -760 {lab=#net46}
N 2140 -760 2220 -760 {lab=#net46}
N 2220 -760 2220 -720 {lab=#net46}
N 2230 -860 2250 -860 {lab=#net47}
N 2250 -860 2250 -830 {lab=#net47}
N 2040 0 2090 0 {lab=S0_1}
N 2020 -670 2070 -670 {lab=S0_0}
N 2690 -330 2740 -330 {lab=S1_0}
N 2090 50 2100 50 {lab=S0_1}
N 2090 30 2090 50 {lab=S0_1}
N 2140 0 2140 20 {lab=#net52}
N 2120 -670 2120 -630 {lab=#net46}
N 2120 -650 2220 -650 {lab=#net46}
N 2070 -640 2070 -600 {lab=S0_0}
N 2070 -600 2080 -600 {lab=S0_0}
N 2740 -300 2740 -280 {lab=S1_0}
N 2740 -280 2750 -280 {lab=S1_0}
N 2790 -330 2790 -310 {lab=#net49}
N 2790 -320 2890 -320 {lab=#net49}
N 2140 10 2240 10 {lab=#net52}
N 2790 -280 2810 -280 {lab=gnd}
C {ipin.sym} -1490 3180 0 0 {name=p198 lab=gnd
}
C {ipin.sym} -1490 3160 0 0 {name=p199 lab=Vdd
}
C {ipin.sym} -1590 3130 0 0 {name=p203 lab=B0_0
}
C {sky130_fd_pr/pfet_01v8.sym} 410 3610 0 0 {name=M37
W=4
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 340 3780 0 0 {name=M38
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 410 3690 0 0 {name=M39
W=4
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 470 3780 0 0 {name=M40
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 360 3810 3 0 {name=p58 sig_type=std_logic lab=gnd}
C {lab_pin.sym} 490 3810 3 0 {name=p59 sig_type=std_logic lab=gnd}
C {sky130_fd_pr/pfet_01v8.sym} 600 3700 0 0 {name=M43
W=2
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 600 3760 0 0 {name=M44
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 410 3910 0 0 {name=M41
W=4
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 340 4080 0 0 {name=M42
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 410 3990 0 0 {name=M45
W=4
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 470 4080 0 0 {name=M46
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 360 4110 3 0 {name=p66 sig_type=std_logic lab=gnd}
C {lab_pin.sym} 490 4110 3 0 {name=p67 sig_type=std_logic lab=gnd}
C {sky130_fd_pr/pfet_01v8.sym} 600 4000 0 0 {name=M47
W=2
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 600 4060 0 0 {name=M48
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 410 4220 0 0 {name=M49
W=4
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 340 4390 0 0 {name=M50
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 410 4300 0 0 {name=M51
W=4
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 470 4390 0 0 {name=M52
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 360 4420 3 0 {name=p74 sig_type=std_logic lab=gnd}
C {lab_pin.sym} 490 4420 3 0 {name=p75 sig_type=std_logic lab=gnd}
C {sky130_fd_pr/pfet_01v8.sym} 600 4310 0 0 {name=M53
W=2
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 600 4370 0 0 {name=M54
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 410 4500 0 0 {name=M55
W=4
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 340 4670 0 0 {name=M56
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 410 4580 0 0 {name=M57
W=4
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 470 4670 0 0 {name=M58
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 360 4700 3 0 {name=p82 sig_type=std_logic lab=gnd}
C {lab_pin.sym} 490 4700 3 0 {name=p83 sig_type=std_logic lab=gnd}
C {sky130_fd_pr/pfet_01v8.sym} 600 4590 0 0 {name=M59
W=2
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 600 4650 0 0 {name=M60
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 600 2190 0 0 {name=M61
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 380 2270 0 0 {name=M62
W=2
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 300 2070 0 0 {name=M63
W=2
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 470 2070 0 0 {name=M64
W=2
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 380 2190 0 0 {name=M65
W=2
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 600 2100 0 0 {name=M66
W=2
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 620 2220 3 0 {name=p85 sig_type=std_logic lab=gnd}
C {lab_pin.sym} 620 3790 3 0 {name=p92 sig_type=std_logic lab=gnd}
C {lab_pin.sym} 400 2300 3 0 {name=p93 sig_type=std_logic lab=gnd}
C {lab_pin.sym} 440 3580 1 0 {name=p57 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 620 3670 1 0 {name=p94 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 430 3880 1 0 {name=p65 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 620 3970 1 0 {name=p95 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 620 4090 3 0 {name=p96 sig_type=std_logic lab=gnd}
C {lab_pin.sym} 490 2040 1 0 {name=p86 sig_type=std_logic lab=Vdd}
C {sky130_fd_pr/nfet_01v8.sym} 590 2520 0 0 {name=M67
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 370 2600 0 0 {name=M68
W=2
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 290 2400 0 0 {name=M69
W=2
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 460 2400 0 0 {name=M70
W=2
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 370 2520 0 0 {name=M71
W=2
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 590 2430 0 0 {name=M72
W=2
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 610 2550 3 0 {name=p100 sig_type=std_logic lab=gnd}
C {lab_pin.sym} 390 2630 3 0 {name=p101 sig_type=std_logic lab=gnd}
C {lab_pin.sym} 480 2370 1 0 {name=p102 sig_type=std_logic lab=Vdd}
C {sky130_fd_pr/nfet_01v8.sym} 590 2860 0 0 {name=M73
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 370 2940 0 0 {name=M74
W=2
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 290 2740 0 0 {name=M75
W=2
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 460 2740 0 0 {name=M76
W=2
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 370 2860 0 0 {name=M77
W=2
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 590 2770 0 0 {name=M78
W=2
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 610 2890 3 0 {name=p108 sig_type=std_logic lab=gnd}
C {lab_pin.sym} 390 2970 3 0 {name=p109 sig_type=std_logic lab=gnd}
C {lab_pin.sym} 480 2710 1 0 {name=p110 sig_type=std_logic lab=Vdd}
C {sky130_fd_pr/nfet_01v8.sym} 580 3200 0 0 {name=M79
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 360 3280 0 0 {name=M80
W=2
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 280 3080 0 0 {name=M81
W=2
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 450 3080 0 0 {name=M82
W=2
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 360 3200 0 0 {name=M83
W=2
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 580 3110 0 0 {name=M84
W=2
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 600 3230 3 0 {name=p116 sig_type=std_logic lab=gnd}
C {lab_pin.sym} 380 3310 3 0 {name=p117 sig_type=std_logic lab=gnd}
C {lab_pin.sym} 470 3050 1 0 {name=p118 sig_type=std_logic lab=Vdd}
C {sky130_fd_pr/pfet_01v8.sym} 430 570 0 0 {name=M85
W=4
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 360 770 0 0 {name=M86
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 430 650 0 0 {name=M87
W=4
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 490 770 0 0 {name=M88
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 380 800 3 0 {name=p126 sig_type=std_logic lab=gnd}
C {lab_pin.sym} 510 800 3 0 {name=p127 sig_type=std_logic lab=gnd}
C {lab_pin.sym} 450 540 1 0 {name=p125 sig_type=std_logic lab=Vdd}
C {sky130_fd_pr/pfet_01v8.sym} 430 900 0 0 {name=M89
W=4
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 360 1100 0 0 {name=M90
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 430 980 0 0 {name=M91
W=4
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 490 1100 0 0 {name=M92
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 380 1130 3 0 {name=p131 sig_type=std_logic lab=gnd}
C {lab_pin.sym} 510 1130 3 0 {name=p132 sig_type=std_logic lab=gnd}
C {lab_pin.sym} 450 870 1 0 {name=p134 sig_type=std_logic lab=Vdd}
C {sky130_fd_pr/pfet_01v8.sym} 440 1270 0 0 {name=M93
W=4
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 370 1470 0 0 {name=M94
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 440 1350 0 0 {name=M95
W=4
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 500 1470 0 0 {name=M96
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 390 1500 3 0 {name=p139 sig_type=std_logic lab=gnd}
C {lab_pin.sym} 520 1500 3 0 {name=p140 sig_type=std_logic lab=gnd}
C {lab_pin.sym} 460 1240 1 0 {name=p142 sig_type=std_logic lab=Vdd}
C {sky130_fd_pr/pfet_01v8.sym} 440 1600 0 0 {name=M97
W=4
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 370 1800 0 0 {name=M98
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 440 1680 0 0 {name=M99
W=4
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 500 1800 0 0 {name=M100
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 390 1830 3 0 {name=p147 sig_type=std_logic lab=gnd}
C {lab_pin.sym} 520 1830 3 0 {name=p148 sig_type=std_logic lab=gnd}
C {lab_pin.sym} 460 1570 1 0 {name=p150 sig_type=std_logic lab=Vdd}
C {sky130_fd_pr/nfet_01v8.sym} 460 -990 0 0 {name=M269
W=2
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 380 -1190 0 0 {name=M270
W=2
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 550 -1190 0 0 {name=M271
W=2
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 460 -1070 0 0 {name=M272
W=2
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 530 -1190 0 0 {name=p361 sig_type=std_logic lab=B0_0}
C {lab_pin.sym} 440 -1070 0 0 {name=p362 sig_type=std_logic lab=A0_0}
C {lab_pin.sym} 490 -1250 1 0 {name=p357 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 480 -940 3 0 {name=p363 sig_type=std_logic lab=gnd}
C {lab_pin.sym} 360 -1190 0 0 {name=p358 sig_type=std_logic lab=A0_0}
C {lab_pin.sym} 440 -990 0 0 {name=p359 sig_type=std_logic lab=B0_0}
C {sky130_fd_pr/nfet_01v8.sym} 450 -570 0 0 {name=M273
W=2
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 370 -770 0 0 {name=M274
W=2
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 540 -770 0 0 {name=M275
W=2
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 450 -650 0 0 {name=M276
W=2
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 520 -770 0 0 {name=p365 sig_type=std_logic lab=B1_0}
C {lab_pin.sym} 430 -650 0 0 {name=p366 sig_type=std_logic lab=A1_0}
C {lab_pin.sym} 480 -830 1 0 {name=p367 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 470 -520 3 0 {name=p368 sig_type=std_logic lab=gnd}
C {lab_pin.sym} 350 -770 0 0 {name=p369 sig_type=std_logic lab=A1_0}
C {lab_pin.sym} 430 -570 0 0 {name=p370 sig_type=std_logic lab=B1_0}
C {sky130_fd_pr/nfet_01v8.sym} 450 -170 0 0 {name=M277
W=2
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 370 -370 0 0 {name=M278
W=2
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 540 -370 0 0 {name=M279
W=2
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 450 -250 0 0 {name=M280
W=2
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 520 -370 0 0 {name=p372 sig_type=std_logic lab=B2_0}
C {lab_pin.sym} 430 -250 0 0 {name=p373 sig_type=std_logic lab=A2_0}
C {lab_pin.sym} 480 -430 1 0 {name=p374 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 470 -120 3 0 {name=p375 sig_type=std_logic lab=gnd}
C {lab_pin.sym} 350 -370 0 0 {name=p376 sig_type=std_logic lab=A2_0}
C {lab_pin.sym} 430 -170 0 0 {name=p377 sig_type=std_logic lab=B2_0}
C {sky130_fd_pr/nfet_01v8.sym} 440 230 0 0 {name=M281
W=2
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 360 30 0 0 {name=M282
W=2
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 530 30 0 0 {name=M283
W=2
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 440 150 0 0 {name=M284
W=2
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 510 30 0 0 {name=p379 sig_type=std_logic lab=B3_0}
C {lab_pin.sym} 420 150 0 0 {name=p380 sig_type=std_logic lab=A3_0}
C {lab_pin.sym} 470 -30 1 0 {name=p381 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 460 280 3 0 {name=p382 sig_type=std_logic lab=gnd}
C {lab_pin.sym} 340 30 0 0 {name=p383 sig_type=std_logic lab=A3_0}
C {lab_pin.sym} 420 230 0 0 {name=p384 sig_type=std_logic lab=B3_0}
C {lab_pin.sym} 1050 -1120 2 0 {name=p5 sig_type=std_logic lab=NAND0}
C {lab_pin.sym} 1040 -700 2 0 {name=p7 sig_type=std_logic lab=NAND1}
C {lab_pin.sym} 1040 -300 2 0 {name=p9 sig_type=std_logic lab=NAND2}
C {lab_pin.sym} 1030 100 2 0 {name=p12 sig_type=std_logic lab=NAND3}
C {lab_pin.sym} 1010 700 2 0 {name=p13 sig_type=std_logic lab=NOR0}
C {lab_pin.sym} 1010 1030 2 0 {name=p14 sig_type=std_logic lab=NOR1}
C {lab_pin.sym} 1020 1400 2 0 {name=p15 sig_type=std_logic lab=NOR2}
C {lab_pin.sym} 1020 1730 2 0 {name=p16 sig_type=std_logic lab=NOR3}
C {lab_pin.sym} 1050 2140 2 0 {name=p21 sig_type=std_logic lab=AND0}
C {lab_pin.sym} 1030 2470 2 0 {name=p30 sig_type=std_logic lab=AND1}
C {lab_pin.sym} 1040 2810 2 0 {name=p31 sig_type=std_logic lab=AND2}
C {lab_pin.sym} 1030 3150 2 0 {name=p32 sig_type=std_logic lab=AND3}
C {lab_pin.sym} 620 3730 2 0 {name=p33 sig_type=std_logic lab=OR0}
C {lab_pin.sym} 620 4030 2 0 {name=p34 sig_type=std_logic lab=OR1}
C {lab_pin.sym} 620 4340 2 0 {name=p35 sig_type=std_logic lab=OR2}
C {lab_pin.sym} 620 4620 2 0 {name=p36 sig_type=std_logic lab=OR3}
C {lab_pin.sym} 430 4470 1 0 {name=p53 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 620 4560 1 0 {name=p54 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 430 4190 1 0 {name=p55 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 620 4280 1 0 {name=p56 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 620 4680 3 0 {name=p197 sig_type=std_logic lab=gnd}
C {lab_pin.sym} 620 4400 3 0 {name=p248 sig_type=std_logic lab=gnd}
C {ipin.sym} -1680 3130 0 0 {name=p1 lab=A0_0}
C {ipin.sym} -1480 3220 0 0 {name=p64 lab=S0_0
}
C {vsource.sym} -1320 840 0 0 {name=V2 value="pwl(0n 1.8 1n 1.8 1.01n 0 4n 0 4.01n 1.8 5n 1.8 5.01n 0)" savecurrent=false
spice_ignore=true}
C {gnd.sym} -1320 870 0 0 {name=l2 lab=GND
spice_ignore=true}
C {vsource.sym} -810 850 0 0 {name=V3 value="pwl(0n 0 3n 0 3.01n 1.8 5n 1.8 5.01n 0)" savecurrent=false
spice_ignore=true}
C {gnd.sym} -810 880 0 0 {name=l3 lab=GND
spice_ignore=true}
C {vsource.sym} -1320 950 0 0 {name=V4 value="pwl(0n 1.8 1n 1.8 1.01n 0 2n 0 2.01n 1.8 4n 1.8 4.01n 0 6n 0 6.01n 1.8 7n 1.8 7.01n 0)" savecurrent=false
spice_ignore=true}
C {gnd.sym} -1320 980 0 0 {name=l4 lab=GND
spice_ignore=true}
C {vsource.sym} -810 950 0 0 {name=V5 value="pwl(0n 0 1n 0 1.01n 1.8 4n 1.8 4.01n 0 6n 0 6.01n 1.8)" savecurrent=false
spice_ignore=true}
C {gnd.sym} -810 980 0 0 {name=l5 lab=GND
spice_ignore=true}
C {vsource.sym} -1320 1070 0 0 {name=V6 value="pwl(0n 0 7n 0 7.01n 1.8)" savecurrent=false
spice_ignore=true}
C {gnd.sym} -1320 1100 0 0 {name=l6 lab=GND
spice_ignore=true}
C {vsource.sym} -810 1050 0 0 {name=V7 value="pwl(0n 1.8 1n 1.8 1.01n 0 2n 0 2.01n 1.8 3n 1.8 3.01n 0 4n 0 4.01n 1.8 5n 1.8 5.01n 0 6n 0 6.01n 1.8)" savecurrent=false
spice_ignore=true}
C {gnd.sym} -810 1080 0 0 {name=l7 lab=GND
spice_ignore=true}
C {vsource.sym} -1320 1170 0 0 {name=V8 value="pwl(0n 0 1n 0 1.01n 1.8 3n 1.8 3.01n 0 4n 0 4.01n 1.8)" savecurrent=false
spice_ignore=true}
C {gnd.sym} -1320 1200 0 0 {name=l8 lab=GND
spice_ignore=true}
C {vsource.sym} -810 1150 0 0 {name=V9 value="pwl(0n 0 4n 0 4.01n 1.8 6n 1.8 6.01n 0)" savecurrent=false
spice_ignore=true}
C {gnd.sym} -810 1180 0 0 {name=l9 lab=GND
spice_ignore=true}
C {lab_pin.sym} -1320 810 0 0 {name=p283 sig_type=std_logic lab=A0
spice_ignore=true}
C {lab_pin.sym} -810 820 0 0 {name=p284 sig_type=std_logic lab=B0
spice_ignore=true}
C {lab_pin.sym} -1320 920 0 0 {name=p285 sig_type=std_logic lab=A1
spice_ignore=true}
C {lab_pin.sym} -810 920 0 0 {name=p286 sig_type=std_logic lab=B1
spice_ignore=true}
C {lab_pin.sym} -1320 1040 0 0 {name=p287 sig_type=std_logic lab=A2
spice_ignore=true}
C {lab_pin.sym} -810 1020 0 0 {name=p288 sig_type=std_logic lab=B2
spice_ignore=true}
C {lab_pin.sym} -1320 1140 0 0 {name=p289 sig_type=std_logic lab=A3
spice_ignore=true}
C {lab_pin.sym} -810 1120 0 0 {name=p290 sig_type=std_logic lab=B3
spice_ignore=true}
C {vsource.sym} -430 700 0 0 {name=V10 value="pwl(0n 0 4n 0 4.01n 1.8)" savecurrent=false
spice_ignore=true}
C {gnd.sym} -430 730 0 0 {name=l10 lab=GND
spice_ignore=true}
C {vsource.sym} -570 2560 0 0 {name=V11 value="pwl(0n 0 2n 0 2.01n 1.8 4n 1.8 4.01n 0 6n 0 6.01n 1.8)" savecurrent=false
}
C {gnd.sym} -570 2590 0 0 {name=l11 lab=GND
}
C {lab_pin.sym} -430 670 0 0 {name=p291 sig_type=std_logic lab=S2
spice_ignore=true}
C {lab_pin.sym} -570 2530 0 0 {name=p292 sig_type=std_logic lab=S1_0
}
C {vsource.sym} -800 2560 0 0 {name=V12 value="pulse(0 1.8 1n 10ps 10ps 1n 2n)" savecurrent=false
}
C {gnd.sym} -800 2590 0 0 {name=l12 lab=GND
}
C {lab_pin.sym} -800 2530 0 0 {name=p293 sig_type=std_logic lab=S0_0
}
C {code_shown.sym} -1950 1820 0 0 {name=s1 only_toplevel=false value=".lib /home/prime/vlsi_/open_pdks/sources/sky130_fd_pr/models/sky130.lib.spice tt
.tran 0.2n 8n
.save all
.end"
}
C {lab_pin.sym} -440 1960 0 0 {name=p294 sig_type=std_logic lab=Vdd
}
C {vsource.sym} -440 1990 0 0 {name=V1 value=1.8 savecurrent=false
}
C {gnd.sym} -440 2020 0 0 {name=l1 lab=GND
}
C {lab_pin.sym} 410 570 0 0 {name=p121 sig_type=std_logic lab=A0_1}
C {lab_pin.sym} 410 650 0 0 {name=p122 sig_type=std_logic lab=B0_1}
C {lab_pin.sym} 340 770 0 0 {name=p123 sig_type=std_logic lab=A0_1}
C {lab_pin.sym} 470 770 0 0 {name=p124 sig_type=std_logic lab=B0_1}
C {lab_pin.sym} 410 900 0 0 {name=p129 sig_type=std_logic lab=A1_1}
C {lab_pin.sym} 410 980 0 0 {name=p130 sig_type=std_logic lab=B1_1}
C {lab_pin.sym} 340 1100 0 0 {name=p135 sig_type=std_logic lab=A1_1}
C {lab_pin.sym} 470 1100 0 0 {name=p136 sig_type=std_logic lab=B1_1}
C {lab_pin.sym} 420 1270 0 0 {name=p143 sig_type=std_logic lab=A2_1}
C {lab_pin.sym} 420 1350 0 0 {name=p144 sig_type=std_logic lab=B2_1}
C {lab_pin.sym} 350 1470 0 0 {name=p137 sig_type=std_logic lab=A2_1}
C {lab_pin.sym} 480 1470 0 0 {name=p138 sig_type=std_logic lab=B2_1}
C {lab_pin.sym} 420 1600 0 0 {name=p151 sig_type=std_logic lab=A3_1}
C {lab_pin.sym} 420 1680 0 0 {name=p152 sig_type=std_logic lab=B3_1}
C {lab_pin.sym} 350 1800 0 0 {name=p145 sig_type=std_logic lab=A3_1}
C {lab_pin.sym} 480 1800 0 0 {name=p146 sig_type=std_logic lab=B3_1}
C {lab_pin.sym} 280 2070 0 0 {name=p87 sig_type=std_logic lab=A0_2}
C {lab_pin.sym} 450 2070 0 0 {name=p90 sig_type=std_logic lab=B0_2}
C {lab_pin.sym} 360 2190 0 0 {name=p88 sig_type=std_logic lab=A0_2}
C {lab_pin.sym} 360 2270 0 0 {name=p91 sig_type=std_logic lab=B0_2}
C {lab_pin.sym} 270 2400 0 0 {name=p98 sig_type=std_logic lab=A1_2}
C {lab_pin.sym} 440 2400 0 0 {name=p103 sig_type=std_logic lab=B1_2}
C {lab_pin.sym} 350 2520 0 0 {name=p99 sig_type=std_logic lab=A1_2}
C {lab_pin.sym} 350 2600 0 0 {name=p104 sig_type=std_logic lab=B1_2}
C {lab_pin.sym} 270 2740 0 0 {name=p106 sig_type=std_logic lab=A2_2}
C {lab_pin.sym} 440 2740 0 0 {name=p111 sig_type=std_logic lab=B2_2}
C {lab_pin.sym} 350 2860 0 0 {name=p107 sig_type=std_logic lab=A2_2}
C {lab_pin.sym} 350 2940 0 0 {name=p112 sig_type=std_logic lab=B2_2}
C {lab_pin.sym} 260 3080 0 0 {name=p114 sig_type=std_logic lab=A3_2}
C {lab_pin.sym} 430 3080 0 0 {name=p119 sig_type=std_logic lab=B3_2}
C {lab_pin.sym} 340 3200 0 0 {name=p115 sig_type=std_logic lab=A3_2}
C {lab_pin.sym} 340 3280 0 0 {name=p120 sig_type=std_logic lab=B3_2}
C {lab_pin.sym} 390 3610 0 0 {name=p37 sig_type=std_logic lab=A0_3}
C {lab_pin.sym} 390 3690 0 0 {name=p38 sig_type=std_logic lab=B0_3}
C {lab_pin.sym} 320 3780 0 0 {name=p39 sig_type=std_logic lab=A0_3}
C {lab_pin.sym} 450 3780 0 0 {name=p40 sig_type=std_logic lab=B0_3}
C {lab_pin.sym} 390 3910 0 0 {name=p41 sig_type=std_logic lab=A1_3}
C {lab_pin.sym} 390 3990 0 0 {name=p42 sig_type=std_logic lab=B1_3}
C {lab_pin.sym} 320 4080 0 0 {name=p43 sig_type=std_logic lab=A1_3}
C {lab_pin.sym} 450 4080 0 0 {name=p44 sig_type=std_logic lab=B1_3}
C {lab_pin.sym} 390 4220 0 0 {name=p45 sig_type=std_logic lab=A2_3}
C {lab_pin.sym} 390 4300 0 0 {name=p46 sig_type=std_logic lab=B2_3}
C {lab_pin.sym} 320 4390 0 0 {name=p47 sig_type=std_logic lab=A2_3}
C {lab_pin.sym} 450 4390 0 0 {name=p48 sig_type=std_logic lab=B2_3}
C {lab_pin.sym} 390 4500 0 0 {name=p49 sig_type=std_logic lab=A3_3}
C {lab_pin.sym} 390 4580 0 0 {name=p50 sig_type=std_logic lab=B3_3}
C {lab_pin.sym} 320 4670 0 0 {name=p51 sig_type=std_logic lab=A3_3}
C {lab_pin.sym} 450 4670 0 0 {name=p52 sig_type=std_logic lab=B3_3}
C {ipin.sym} -1680 3150 0 0 {name=p282 lab=A0_1}
C {ipin.sym} -1680 3170 0 0 {name=p295 lab=A0_2}
C {ipin.sym} -1680 3190 0 0 {name=p296 lab=A0_3}
C {ipin.sym} -1590 3150 0 0 {name=p297 lab=B0_1}
C {ipin.sym} -1590 3170 0 0 {name=p298 lab=B0_2
}
C {ipin.sym} -1590 3190 0 0 {name=p299 lab=B0_3
}
C {ipin.sym} -1680 3230 0 0 {name=p300 lab=A1_0}
C {ipin.sym} -1680 3250 0 0 {name=p301 lab=A1_1}
C {ipin.sym} -1680 3270 0 0 {name=p302 lab=A1_2}
C {ipin.sym} -1680 3290 0 0 {name=p303 lab=A1_3}
C {ipin.sym} -1680 3330 0 0 {name=p304 lab=A2_0}
C {ipin.sym} -1680 3350 0 0 {name=p305 lab=A2_1}
C {ipin.sym} -1680 3370 0 0 {name=p306 lab=A2_2}
C {ipin.sym} -1680 3390 0 0 {name=p307 lab=A2_3}
C {ipin.sym} -1680 3430 0 0 {name=p308 lab=A3_0}
C {ipin.sym} -1680 3450 0 0 {name=p309 lab=A3_1}
C {ipin.sym} -1680 3470 0 0 {name=p310 lab=A3_2}
C {ipin.sym} -1680 3490 0 0 {name=p311 lab=A3_3}
C {ipin.sym} -1590 3230 0 0 {name=p200 lab=B1_0
}
C {ipin.sym} -1590 3250 0 0 {name=p201 lab=B1_1}
C {ipin.sym} -1590 3270 0 0 {name=p202 lab=B1_2
}
C {ipin.sym} -1590 3290 0 0 {name=p205 lab=B1_3
}
C {ipin.sym} -1590 3330 0 0 {name=p213 lab=B2_0
}
C {ipin.sym} -1590 3350 0 0 {name=p217 lab=B2_1}
C {ipin.sym} -1590 3370 0 0 {name=p312 lab=B2_2
}
C {ipin.sym} -1590 3390 0 0 {name=p313 lab=B2_3
}
C {ipin.sym} -1590 3430 0 0 {name=p314 lab=B3_0
}
C {ipin.sym} -1590 3450 0 0 {name=p315 lab=B3_1}
C {ipin.sym} -1590 3470 0 0 {name=p316 lab=B3_2
}
C {ipin.sym} -1590 3490 0 0 {name=p317 lab=B3_3
}
C {ipin.sym} -1480 3240 0 0 {name=p318 lab=S0_1
}
C {ipin.sym} -1480 3260 0 0 {name=p319 lab=S0_2}
C {ipin.sym} -1480 3280 0 0 {name=p320 lab=S0_3
}
C {ipin.sym} -1480 3300 0 0 {name=p321 lab=S0_4
}
C {ipin.sym} -1480 3320 0 0 {name=p322 lab=S0_5}
C {ipin.sym} -1480 3340 0 0 {name=p323 lab=S0_6}
C {ipin.sym} -1480 3360 0 0 {name=p324 lab=S0_7
}
C {sky130_fd_pr/pfet_01v8.sym} 2260 3370 3 0 {name=M129
W=1
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2260 3450 1 0 {name=M130
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2260 3470 3 0 {name=p185 sig_type=std_logic lab=gnd
}
C {lab_pin.sym} 2260 3350 1 0 {name=p186 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 2080 3600 0 0 {name=p187 sig_type=std_logic lab=S0_6}
C {sky130_fd_pr/pfet_01v8.sym} 2160 3570 0 0 {name=M131
W=2
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2160 3670 0 0 {name=M132
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2180 3540 1 0 {name=p189 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 2180 3700 3 0 {name=p190 sig_type=std_logic lab=gnd}
C {sky130_fd_pr/pfet_01v8.sym} 2280 3750 3 0 {name=M133
W=1
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2280 3850 1 0 {name=M134
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2280 3870 3 0 {name=p191 sig_type=std_logic lab=gnd
}
C {lab_pin.sym} 2280 3730 1 0 {name=p192 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 2230 3410 0 0 {name=p193 sig_type=std_logic lab=NAND3}
C {lab_pin.sym} 2250 3810 0 0 {name=p194 sig_type=std_logic lab=NOR3}
C {sky130_fd_pr/pfet_01v8.sym} 2940 3690 1 0 {name=M135
W=1
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2950 3870 3 0 {name=M136
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2950 3850 1 0 {name=p195 sig_type=std_logic lab=gnd
}
C {lab_pin.sym} 2940 3710 3 0 {name=p196 sig_type=std_logic lab=Vdd}
C {sky130_fd_pr/pfet_01v8.sym} 2830 3910 0 0 {name=M139
W=2
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2830 3990 0 0 {name=M140
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2750 3940 0 0 {name=p207 sig_type=std_logic lab=S1_3}
C {lab_pin.sym} 2850 3880 1 0 {name=p208 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 2850 4020 3 0 {name=p209 sig_type=std_logic lab=gnd}
C {sky130_fd_pr/pfet_01v8.sym} 2950 4090 1 0 {name=M141
W=1
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2960 4270 3 0 {name=M142
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2960 4250 1 0 {name=p210 sig_type=std_logic lab=gnd
}
C {lab_pin.sym} 2950 4110 3 0 {name=p211 sig_type=std_logic lab=Vdd}
C {sky130_fd_pr/nfet_01v8.sym} 3160 4000 0 0 {name=M143
W=2
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3160 3940 0 0 {name=M144
W=4
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 3180 4030 3 0 {name=p212 sig_type=std_logic lab=gnd}
C {lab_pin.sym} 3180 3910 1 0 {name=p214 sig_type=std_logic lab=Vdd}
C {sky130_fd_pr/nfet_01v8.sym} 3400 4000 0 0 {name=M145
W=2
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3400 3940 0 0 {name=M146
W=4
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 3420 4030 3 0 {name=p215 sig_type=std_logic lab=gnd}
C {lab_pin.sym} 3420 3910 1 0 {name=p216 sig_type=std_logic lab=Vdd}
C {sky130_fd_pr/pfet_01v8.sym} 2290 4020 1 0 {name=M147
W=1
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2300 4200 3 0 {name=M148
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2300 4180 1 0 {name=p218 sig_type=std_logic lab=gnd
}
C {lab_pin.sym} 2290 4040 3 0 {name=p219 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 2100 4270 0 0 {name=p220 sig_type=std_logic lab=S0_7}
C {sky130_fd_pr/pfet_01v8.sym} 2180 4240 0 0 {name=M149
W=2
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2180 4320 0 0 {name=M150
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2200 4210 1 0 {name=p221 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 2200 4350 3 0 {name=p222 sig_type=std_logic lab=gnd}
C {sky130_fd_pr/pfet_01v8.sym} 2300 4420 1 0 {name=M151
W=1
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2310 4600 3 0 {name=M152
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2310 4580 1 0 {name=p223 sig_type=std_logic lab=gnd
}
C {lab_pin.sym} 2300 4440 3 0 {name=p224 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 2260 4120 0 0 {name=p225 sig_type=std_logic lab=AND3}
C {lab_pin.sym} 2270 4520 0 0 {name=p228 sig_type=std_logic lab=OR3}
C {opin.sym} 3540 3970 0 0 {name=p229 lab=F3}
C {sky130_fd_pr/pfet_01v8.sym} 2240 1920 3 0 {name=M1
W=1
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2240 2000 1 0 {name=M2
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2240 2020 3 0 {name=p2 sig_type=std_logic lab=gnd
}
C {lab_pin.sym} 2240 1900 1 0 {name=p3 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 2060 2150 0 0 {name=p4 sig_type=std_logic lab=S0_4}
C {sky130_fd_pr/pfet_01v8.sym} 2140 2120 0 0 {name=M3
W=2
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2140 2220 0 0 {name=M4
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2160 2090 1 0 {name=p6 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 2160 2250 3 0 {name=p8 sig_type=std_logic lab=gnd}
C {sky130_fd_pr/pfet_01v8.sym} 2260 2300 3 0 {name=M5
W=1
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2260 2400 1 0 {name=M6
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2260 2420 3 0 {name=p10 sig_type=std_logic lab=gnd
}
C {lab_pin.sym} 2260 2280 1 0 {name=p11 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 2210 1960 0 0 {name=p17 sig_type=std_logic lab=NAND2}
C {lab_pin.sym} 2230 2360 0 0 {name=p18 sig_type=std_logic lab=NOR2}
C {sky130_fd_pr/pfet_01v8.sym} 2920 2240 1 0 {name=M7
W=1
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2930 2420 3 0 {name=M8
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2930 2400 1 0 {name=p19 sig_type=std_logic lab=gnd
}
C {lab_pin.sym} 2920 2260 3 0 {name=p20 sig_type=std_logic lab=Vdd}
C {sky130_fd_pr/pfet_01v8.sym} 2810 2460 0 0 {name=M9
W=2
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2810 2540 0 0 {name=M10
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2730 2490 0 0 {name=p22 sig_type=std_logic lab=S1_2}
C {lab_pin.sym} 2830 2430 1 0 {name=p23 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 2830 2570 3 0 {name=p24 sig_type=std_logic lab=gnd}
C {sky130_fd_pr/pfet_01v8.sym} 2930 2640 1 0 {name=M11
W=1
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2940 2820 3 0 {name=M12
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2940 2800 1 0 {name=p25 sig_type=std_logic lab=gnd
}
C {lab_pin.sym} 2930 2660 3 0 {name=p26 sig_type=std_logic lab=Vdd}
C {sky130_fd_pr/nfet_01v8.sym} 3140 2550 0 0 {name=M13
W=2
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3140 2490 0 0 {name=M14
W=4
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 3160 2580 3 0 {name=p27 sig_type=std_logic lab=gnd}
C {lab_pin.sym} 3160 2460 1 0 {name=p28 sig_type=std_logic lab=Vdd}
C {sky130_fd_pr/nfet_01v8.sym} 3380 2550 0 0 {name=M15
W=2
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3380 2490 0 0 {name=M16
W=4
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 3400 2580 3 0 {name=p29 sig_type=std_logic lab=gnd}
C {lab_pin.sym} 3400 2460 1 0 {name=p60 sig_type=std_logic lab=Vdd}
C {sky130_fd_pr/pfet_01v8.sym} 2270 2570 1 0 {name=M17
W=1
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2280 2750 3 0 {name=M18
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2280 2730 1 0 {name=p61 sig_type=std_logic lab=gnd
}
C {lab_pin.sym} 2270 2590 3 0 {name=p62 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 2080 2820 0 0 {name=p63 sig_type=std_logic lab=S0_5}
C {sky130_fd_pr/pfet_01v8.sym} 2160 2790 0 0 {name=M19
W=2
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2160 2870 0 0 {name=M20
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2180 2760 1 0 {name=p68 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 2180 2900 3 0 {name=p69 sig_type=std_logic lab=gnd}
C {sky130_fd_pr/pfet_01v8.sym} 2280 2970 1 0 {name=M21
W=1
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2290 3150 3 0 {name=M22
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2290 3130 1 0 {name=p70 sig_type=std_logic lab=gnd
}
C {lab_pin.sym} 2280 2990 3 0 {name=p71 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 2240 2670 0 0 {name=p72 sig_type=std_logic lab=AND2}
C {lab_pin.sym} 2250 3070 0 0 {name=p73 sig_type=std_logic lab=OR2}
C {opin.sym} 3520 2520 0 0 {name=p76 lab=F2}
C {sky130_fd_pr/pfet_01v8.sym} 2230 500 3 0 {name=M23
W=1
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2230 580 1 0 {name=M24
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2230 600 3 0 {name=p77 sig_type=std_logic lab=gnd
}
C {lab_pin.sym} 2230 480 1 0 {name=p78 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 2050 730 0 0 {name=p79 sig_type=std_logic lab=S0_2}
C {sky130_fd_pr/pfet_01v8.sym} 2130 700 0 0 {name=M25
W=2
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2130 800 0 0 {name=M26
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2150 670 1 0 {name=p80 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 2150 830 3 0 {name=p81 sig_type=std_logic lab=gnd}
C {sky130_fd_pr/pfet_01v8.sym} 2250 880 3 0 {name=M27
W=1
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2250 980 1 0 {name=M28
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2250 1000 3 0 {name=p84 sig_type=std_logic lab=gnd
}
C {lab_pin.sym} 2250 860 1 0 {name=p89 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 2200 540 0 0 {name=p97 sig_type=std_logic lab=NAND1}
C {lab_pin.sym} 2220 940 0 0 {name=p105 sig_type=std_logic lab=NOR1}
C {sky130_fd_pr/pfet_01v8.sym} 2910 820 1 0 {name=M29
W=1
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2920 1000 3 0 {name=M30
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2920 980 1 0 {name=p113 sig_type=std_logic lab=gnd
}
C {lab_pin.sym} 2910 840 3 0 {name=p128 sig_type=std_logic lab=Vdd}
C {sky130_fd_pr/pfet_01v8.sym} 2800 1040 0 0 {name=M31
W=2
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2800 1120 0 0 {name=M32
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2720 1070 0 0 {name=p133 sig_type=std_logic lab=S1_1}
C {lab_pin.sym} 2820 1010 1 0 {name=p141 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 2820 1150 3 0 {name=p149 sig_type=std_logic lab=gnd}
C {sky130_fd_pr/pfet_01v8.sym} 2920 1220 1 0 {name=M33
W=1
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2930 1400 3 0 {name=M34
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2930 1380 1 0 {name=p153 sig_type=std_logic lab=gnd
}
C {lab_pin.sym} 2920 1240 3 0 {name=p154 sig_type=std_logic lab=Vdd}
C {sky130_fd_pr/nfet_01v8.sym} 3130 1130 0 0 {name=M35
W=2
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3130 1070 0 0 {name=M36
W=4
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 3150 1160 3 0 {name=p155 sig_type=std_logic lab=gnd}
C {lab_pin.sym} 3150 1040 1 0 {name=p156 sig_type=std_logic lab=Vdd}
C {sky130_fd_pr/nfet_01v8.sym} 3370 1130 0 0 {name=M101
W=2
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3370 1070 0 0 {name=M102
W=4
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 3390 1160 3 0 {name=p157 sig_type=std_logic lab=gnd}
C {lab_pin.sym} 3390 1040 1 0 {name=p158 sig_type=std_logic lab=Vdd}
C {sky130_fd_pr/pfet_01v8.sym} 2260 1150 1 0 {name=M103
W=1
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2270 1330 3 0 {name=M104
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2270 1310 1 0 {name=p159 sig_type=std_logic lab=gnd
}
C {lab_pin.sym} 2260 1170 3 0 {name=p160 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 2070 1400 0 0 {name=p161 sig_type=std_logic lab=S0_3}
C {sky130_fd_pr/pfet_01v8.sym} 2150 1370 0 0 {name=M105
W=2
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2150 1450 0 0 {name=M106
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2170 1340 1 0 {name=p162 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 2170 1480 3 0 {name=p163 sig_type=std_logic lab=gnd}
C {sky130_fd_pr/pfet_01v8.sym} 2270 1550 1 0 {name=M107
W=1
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2280 1730 3 0 {name=M108
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2280 1710 1 0 {name=p164 sig_type=std_logic lab=gnd
}
C {lab_pin.sym} 2270 1570 3 0 {name=p165 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 2230 1250 0 0 {name=p166 sig_type=std_logic lab=AND1}
C {lab_pin.sym} 2240 1650 0 0 {name=p167 sig_type=std_logic lab=OR1}
C {opin.sym} 3510 1100 0 0 {name=p168 lab=F1}
C {sky130_fd_pr/pfet_01v8.sym} 2200 -900 3 0 {name=M109
W=1
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2200 -820 1 0 {name=M110
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2200 -800 3 0 {name=p169 sig_type=std_logic lab=gnd
}
C {lab_pin.sym} 2200 -920 1 0 {name=p170 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 2020 -670 0 0 {name=p171 sig_type=std_logic lab=S0_0}
C {sky130_fd_pr/pfet_01v8.sym} 2100 -700 0 0 {name=M111
W=2
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2100 -600 0 0 {name=M112
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2120 -730 1 0 {name=p172 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 2120 -570 3 0 {name=p173 sig_type=std_logic lab=gnd}
C {sky130_fd_pr/pfet_01v8.sym} 2220 -520 3 0 {name=M113
W=1
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2220 -420 1 0 {name=M114
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2220 -400 3 0 {name=p174 sig_type=std_logic lab=gnd
}
C {lab_pin.sym} 2220 -540 1 0 {name=p175 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 2170 -860 0 0 {name=p176 sig_type=std_logic lab=NAND0}
C {lab_pin.sym} 2190 -460 0 0 {name=p177 sig_type=std_logic lab=NOR0}
C {sky130_fd_pr/pfet_01v8.sym} 2880 -580 1 0 {name=M115
W=1
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2890 -400 3 0 {name=M116
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2890 -420 1 0 {name=p178 sig_type=std_logic lab=gnd
}
C {lab_pin.sym} 2880 -560 3 0 {name=p179 sig_type=std_logic lab=Vdd}
C {sky130_fd_pr/pfet_01v8.sym} 2770 -360 0 0 {name=M117
W=2
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2770 -280 0 0 {name=M118
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2690 -330 0 0 {name=p180 sig_type=std_logic lab=S1_0}
C {lab_pin.sym} 2790 -390 1 0 {name=p181 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 2790 -250 3 0 {name=p182 sig_type=std_logic lab=gnd}
C {sky130_fd_pr/pfet_01v8.sym} 2890 -180 1 0 {name=M119
W=1
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2900 0 3 0 {name=M120
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2900 -20 1 0 {name=p183 sig_type=std_logic lab=gnd
}
C {lab_pin.sym} 2890 -160 3 0 {name=p184 sig_type=std_logic lab=Vdd}
C {sky130_fd_pr/nfet_01v8.sym} 3100 -270 0 0 {name=M121
W=2
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3100 -330 0 0 {name=M122
W=4
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 3120 -240 3 0 {name=p188 sig_type=std_logic lab=gnd}
C {lab_pin.sym} 3120 -360 1 0 {name=p204 sig_type=std_logic lab=Vdd}
C {sky130_fd_pr/nfet_01v8.sym} 3340 -270 0 0 {name=M123
W=2
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3340 -330 0 0 {name=M124
W=4
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 3360 -240 3 0 {name=p206 sig_type=std_logic lab=gnd}
C {lab_pin.sym} 3360 -360 1 0 {name=p226 sig_type=std_logic lab=Vdd}
C {sky130_fd_pr/pfet_01v8.sym} 2230 -250 1 0 {name=M125
W=1
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2240 -70 3 0 {name=M126
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2240 -90 1 0 {name=p227 sig_type=std_logic lab=gnd
}
C {lab_pin.sym} 2230 -230 3 0 {name=p230 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 2040 0 0 0 {name=p231 sig_type=std_logic lab=S0_1}
C {sky130_fd_pr/pfet_01v8.sym} 2120 -30 0 0 {name=M127
W=2
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2120 50 0 0 {name=M128
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2140 -60 1 0 {name=p232 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 2140 80 3 0 {name=p233 sig_type=std_logic lab=gnd}
C {sky130_fd_pr/pfet_01v8.sym} 2240 150 1 0 {name=M137
W=1
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2250 330 3 0 {name=M138
W=1
L=0.15
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2250 310 1 0 {name=p234 sig_type=std_logic lab=gnd
}
C {lab_pin.sym} 2240 170 3 0 {name=p235 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} 2200 -150 0 0 {name=p236 sig_type=std_logic lab=AND0}
C {lab_pin.sym} 2210 250 0 0 {name=p237 sig_type=std_logic lab=OR0}
C {opin.sym} 3480 -300 0 0 {name=p238 lab=F0}
C {ipin.sym} -1480 3430 0 0 {name=p239 lab=S1_0
}
C {ipin.sym} -1480 3450 0 0 {name=p240 lab=S1_1
}
C {ipin.sym} -1480 3470 0 0 {name=p241 lab=S1_2
}
C {ipin.sym} -1480 3490 0 0 {name=p242 lab=S1_3
}
C {vsource.sym} -800 2660 0 0 {name=V13 value="pulse(0 1.8 1n 10ps 10ps 1n 2n)" savecurrent=false
}
C {gnd.sym} -800 2690 0 0 {name=l13 lab=GND
}
C {lab_pin.sym} -800 2630 0 0 {name=p243 sig_type=std_logic lab=S0_1
}
C {vsource.sym} -800 2760 0 0 {name=V14 value="pulse(0 1.8 1n 10ps 10ps 1n 2n)" savecurrent=false
}
C {gnd.sym} -800 2790 0 0 {name=l14 lab=GND
}
C {lab_pin.sym} -800 2730 0 0 {name=p244 sig_type=std_logic lab=S0_2
}
C {vsource.sym} -800 2860 0 0 {name=V15 value="pulse(0 1.8 1n 10ps 10ps 1n 2n)" savecurrent=false
}
C {gnd.sym} -800 2890 0 0 {name=l15 lab=GND
}
C {lab_pin.sym} -800 2830 0 0 {name=p245 sig_type=std_logic lab=S0_3
}
C {vsource.sym} -800 2960 0 0 {name=V16 value="pulse(0 1.8 1n 10ps 10ps 1n 2n)" savecurrent=false
}
C {gnd.sym} -800 2990 0 0 {name=l16 lab=GND
}
C {lab_pin.sym} -800 2930 0 0 {name=p246 sig_type=std_logic lab=S0_4
}
C {vsource.sym} -800 3060 0 0 {name=V17 value="pulse(0 1.8 1n 10ps 10ps 1n 2n)" savecurrent=false
}
C {gnd.sym} -800 3090 0 0 {name=l17 lab=GND
}
C {lab_pin.sym} -800 3030 0 0 {name=p247 sig_type=std_logic lab=S0_5
}
C {vsource.sym} -800 3160 0 0 {name=V18 value="pulse(0 1.8 1n 10ps 10ps 1n 2n)" savecurrent=false
}
C {gnd.sym} -800 3190 0 0 {name=l18 lab=GND
}
C {lab_pin.sym} -800 3130 0 0 {name=p249 sig_type=std_logic lab=S0_6
}
C {vsource.sym} -800 3260 0 0 {name=V19 value="pulse(0 1.8 1n 10ps 10ps 1n 2n)" savecurrent=false
}
C {gnd.sym} -800 3290 0 0 {name=l19 lab=GND
}
C {lab_pin.sym} -800 3230 0 0 {name=p250 sig_type=std_logic lab=S0_7
}
C {vsource.sym} -570 2660 0 0 {name=V20 value="pwl(0n 0 2n 0 2.01n 1.8 4n 1.8 4.01n 0 6n 0 6.01n 1.8)" savecurrent=false
}
C {gnd.sym} -570 2690 0 0 {name=l20 lab=GND
}
C {lab_pin.sym} -570 2630 0 0 {name=p251 sig_type=std_logic lab=S1_1
}
C {vsource.sym} -570 2760 0 0 {name=V21 value="pwl(0n 0 2n 0 2.01n 1.8 4n 1.8 4.01n 0 6n 0 6.01n 1.8)" savecurrent=false
}
C {gnd.sym} -570 2790 0 0 {name=l21 lab=GND
}
C {lab_pin.sym} -570 2730 0 0 {name=p252 sig_type=std_logic lab=S1_2
}
C {vsource.sym} -570 2860 0 0 {name=V22 value="pwl(0n 0 2n 0 2.01n 1.8 4n 1.8 4.01n 0 6n 0 6.01n 1.8)" savecurrent=false
}
C {gnd.sym} -570 2890 0 0 {name=l22 lab=GND
}
C {lab_pin.sym} -570 2830 0 0 {name=p253 sig_type=std_logic lab=S1_3
}
C {vsource.sym} -1940 2000 0 0 {name=V23 value="pwl(0n 1.8 1n 1.8 1.01n 0 4n 0 4.01n 1.8 5n 1.8 5.01n 0)" savecurrent=false
}
C {gnd.sym} -1940 2030 0 0 {name=l23 lab=GND
}
C {vsource.sym} -2090 2120 0 0 {name=V24 value="pwl(0n 1.8 1n 1.8 1.01n 0 2n 0 2.01n 1.8 4n 1.8 4.01n 0 6n 0 6.01n 1.8 7n 1.8 7.01n 0)" savecurrent=false
}
C {gnd.sym} -2090 2150 0 0 {name=l24 lab=GND
}
C {vsource.sym} -2180 2240 0 0 {name=V25 value="pwl(0n 0 7n 0 7.01n 1.8)" savecurrent=false
}
C {gnd.sym} -2180 2270 0 0 {name=l25 lab=GND
}
C {vsource.sym} -2250 2350 0 0 {name=V26 value="pwl(0n 0 1n 0 1.01n 1.8 3n 1.8 3.01n 0 4n 0 4.01n 1.8)" savecurrent=false
}
C {gnd.sym} -2250 2380 0 0 {name=l26 lab=GND
}
C {lab_pin.sym} -1940 1970 0 0 {name=p254 sig_type=std_logic lab=A0_0
}
C {lab_pin.sym} -2090 2090 0 0 {name=p255 sig_type=std_logic lab=A1_0
}
C {lab_pin.sym} -2180 2210 0 0 {name=p256 sig_type=std_logic lab=A2_0
}
C {lab_pin.sym} -2250 2320 0 0 {name=p257 sig_type=std_logic lab=A3_0
}
C {vsource.sym} -1580 2000 0 0 {name=V27 value="pwl(0n 1.8 1n 1.8 1.01n 0 4n 0 4.01n 1.8 5n 1.8 5.01n 0)" savecurrent=false
}
C {gnd.sym} -1580 2030 0 0 {name=l27 lab=GND
}
C {lab_pin.sym} -1580 1970 0 0 {name=p258 sig_type=std_logic lab=A0_1
}
C {vsource.sym} -1240 1990 0 0 {name=V28 value="pwl(0n 1.8 1n 1.8 1.01n 0 4n 0 4.01n 1.8 5n 1.8 5.01n 0)" savecurrent=false
}
C {gnd.sym} -1240 2020 0 0 {name=l28 lab=GND
}
C {lab_pin.sym} -1240 1960 0 0 {name=p259 sig_type=std_logic lab=A0_2
}
C {vsource.sym} -880 1990 0 0 {name=V29 value="pwl(0n 1.8 1n 1.8 1.01n 0 4n 0 4.01n 1.8 5n 1.8 5.01n 0)" savecurrent=false
}
C {gnd.sym} -880 2020 0 0 {name=l29 lab=GND
}
C {lab_pin.sym} -880 1960 0 0 {name=p260 sig_type=std_logic lab=A0_3
}
C {vsource.sym} -1580 2120 0 0 {name=V30 value="pwl(0n 1.8 1n 1.8 1.01n 0 2n 0 2.01n 1.8 4n 1.8 4.01n 0 6n 0 6.01n 1.8 7n 1.8 7.01n 0)" savecurrent=false
}
C {gnd.sym} -1580 2150 0 0 {name=l30 lab=GND
}
C {lab_pin.sym} -1580 2090 0 0 {name=p261 sig_type=std_logic lab=A1_1
}
C {vsource.sym} -1080 2120 0 0 {name=V31 value="pwl(0n 1.8 1n 1.8 1.01n 0 2n 0 2.01n 1.8 4n 1.8 4.01n 0 6n 0 6.01n 1.8 7n 1.8 7.01n 0)" savecurrent=false
}
C {gnd.sym} -1080 2150 0 0 {name=l31 lab=GND
}
C {lab_pin.sym} -1080 2090 0 0 {name=p262 sig_type=std_logic lab=A1_2
}
C {vsource.sym} -570 2120 0 0 {name=V32 value="pwl(0n 1.8 1n 1.8 1.01n 0 2n 0 2.01n 1.8 4n 1.8 4.01n 0 6n 0 6.01n 1.8 7n 1.8 7.01n 0)" savecurrent=false
}
C {gnd.sym} -570 2150 0 0 {name=l32 lab=GND
}
C {lab_pin.sym} -570 2090 0 0 {name=p263 sig_type=std_logic lab=A1_3
}
C {vsource.sym} -2010 2240 0 0 {name=V33 value="pwl(0n 0 7n 0 7.01n 1.8)" savecurrent=false
}
C {gnd.sym} -2010 2270 0 0 {name=l33 lab=GND
}
C {lab_pin.sym} -2010 2210 0 0 {name=p264 sig_type=std_logic lab=A2_1
}
C {vsource.sym} -1850 2240 0 0 {name=V34 value="pwl(0n 0 7n 0 7.01n 1.8)" savecurrent=false
}
C {gnd.sym} -1850 2270 0 0 {name=l34 lab=GND
}
C {lab_pin.sym} -1850 2210 0 0 {name=p265 sig_type=std_logic lab=A2_2
}
C {vsource.sym} -1680 2240 0 0 {name=V35 value="pwl(0n 0 7n 0 7.01n 1.8)" savecurrent=false
}
C {gnd.sym} -1680 2270 0 0 {name=l35 lab=GND
}
C {lab_pin.sym} -1680 2210 0 0 {name=p266 sig_type=std_logic lab=A2_3
}
C {vsource.sym} -1920 2350 0 0 {name=V36 value="pwl(0n 0 1n 0 1.01n 1.8 3n 1.8 3.01n 0 4n 0 4.01n 1.8)" savecurrent=false
}
C {gnd.sym} -1920 2380 0 0 {name=l36 lab=GND
}
C {lab_pin.sym} -1920 2320 0 0 {name=p267 sig_type=std_logic lab=A3_1
}
C {vsource.sym} -1600 2350 0 0 {name=V37 value="pwl(0n 0 1n 0 1.01n 1.8 3n 1.8 3.01n 0 4n 0 4.01n 1.8)" savecurrent=false
}
C {gnd.sym} -1600 2380 0 0 {name=l37 lab=GND
}
C {lab_pin.sym} -1600 2320 0 0 {name=p268 sig_type=std_logic lab=A3_2
}
C {vsource.sym} -1280 2350 0 0 {name=V38 value="pwl(0n 0 1n 0 1.01n 1.8 3n 1.8 3.01n 0 4n 0 4.01n 1.8)" savecurrent=false
}
C {gnd.sym} -1280 2380 0 0 {name=l38 lab=GND
}
C {lab_pin.sym} -1280 2320 0 0 {name=p269 sig_type=std_logic lab=A3_3
}
C {gnd.sym} -340 2010 0 0 {name=l39 lab=gnd
}
C {vsource.sym} -3320 2610 0 0 {name=V39 value="pwl(0n 0 3n 0 3.01n 1.8 5n 1.8 5.01n 0)" savecurrent=false
}
C {gnd.sym} -3320 2640 0 0 {name=l40 lab=GND
}
C {vsource.sym} -3320 2710 0 0 {name=V40 value="pwl(0n 0 1n 0 1.01n 1.8 4n 1.8 4.01n 0 6n 0 6.01n 1.8)" savecurrent=false
}
C {gnd.sym} -3320 2740 0 0 {name=l41 lab=GND
}
C {vsource.sym} -3320 2810 0 0 {name=V41 value="pwl(0n 1.8 1n 1.8 1.01n 0 2n 0 2.01n 1.8 3n 1.8 3.01n 0 4n 0 4.01n 1.8 5n 1.8 5.01n 0 6n 0 6.01n 1.8)" savecurrent=false
}
C {gnd.sym} -3320 2840 0 0 {name=l42 lab=GND
}
C {vsource.sym} -3320 2910 0 0 {name=V42 value="pwl(0n 0 4n 0 4.01n 1.8 6n 1.8 6.01n 0)" savecurrent=false
}
C {gnd.sym} -3320 2940 0 0 {name=l43 lab=GND
}
C {lab_pin.sym} -3320 2580 0 0 {name=p270 sig_type=std_logic lab=B0_0
}
C {lab_pin.sym} -3320 2680 0 0 {name=p271 sig_type=std_logic lab=B1_0
}
C {lab_pin.sym} -3320 2780 0 0 {name=p272 sig_type=std_logic lab=B2_0
}
C {lab_pin.sym} -3320 2880 0 0 {name=p273 sig_type=std_logic lab=B3_0
}
C {vsource.sym} -3010 2610 0 0 {name=V43 value="pwl(0n 0 3n 0 3.01n 1.8 5n 1.8 5.01n 0)" savecurrent=false
}
C {gnd.sym} -3010 2640 0 0 {name=l44 lab=GND
}
C {lab_pin.sym} -3010 2580 0 0 {name=p274 sig_type=std_logic lab=B0_1
}
C {vsource.sym} -2740 2610 0 0 {name=V44 value="pwl(0n 0 3n 0 3.01n 1.8 5n 1.8 5.01n 0)" savecurrent=false
}
C {gnd.sym} -2740 2640 0 0 {name=l45 lab=GND
}
C {lab_pin.sym} -2740 2580 0 0 {name=p275 sig_type=std_logic lab=B0_2
}
C {vsource.sym} -2430 2610 0 0 {name=V45 value="pwl(0n 0 3n 0 3.01n 1.8 5n 1.8 5.01n 0)" savecurrent=false
}
C {gnd.sym} -2430 2640 0 0 {name=l46 lab=GND
}
C {lab_pin.sym} -2430 2580 0 0 {name=p276 sig_type=std_logic lab=B0_3
}
C {vsource.sym} -3000 2710 0 0 {name=V46 value="pwl(0n 0 1n 0 1.01n 1.8 4n 1.8 4.01n 0 6n 0 6.01n 1.8)" savecurrent=false
}
C {gnd.sym} -3000 2740 0 0 {name=l47 lab=GND
}
C {lab_pin.sym} -3000 2680 0 0 {name=p277 sig_type=std_logic lab=B1_1
}
C {vsource.sym} -2640 2720 0 0 {name=V47 value="pwl(0n 0 1n 0 1.01n 1.8 4n 1.8 4.01n 0 6n 0 6.01n 1.8)" savecurrent=false
}
C {gnd.sym} -2640 2750 0 0 {name=l48 lab=GND
}
C {lab_pin.sym} -2640 2690 0 0 {name=p278 sig_type=std_logic lab=B1_2
}
C {vsource.sym} -2320 2720 0 0 {name=V48 value="pwl(0n 0 1n 0 1.01n 1.8 4n 1.8 4.01n 0 6n 0 6.01n 1.8)" savecurrent=false
}
C {gnd.sym} -2320 2750 0 0 {name=l49 lab=GND
}
C {lab_pin.sym} -2320 2690 0 0 {name=p279 sig_type=std_logic lab=B1_3
}
C {vsource.sym} -2730 2810 0 0 {name=V49 value="pwl(0n 1.8 1n 1.8 1.01n 0 2n 0 2.01n 1.8 3n 1.8 3.01n 0 4n 0 4.01n 1.8 5n 1.8 5.01n 0 6n 0 6.01n 1.8)" savecurrent=false
}
C {gnd.sym} -2730 2840 0 0 {name=l50 lab=GND
}
C {lab_pin.sym} -2730 2780 0 0 {name=p280 sig_type=std_logic lab=B2_1
}
C {vsource.sym} -2150 2810 0 0 {name=V50 value="pwl(0n 1.8 1n 1.8 1.01n 0 2n 0 2.01n 1.8 3n 1.8 3.01n 0 4n 0 4.01n 1.8 5n 1.8 5.01n 0 6n 0 6.01n 1.8)" savecurrent=false
}
C {gnd.sym} -2150 2840 0 0 {name=l51 lab=GND
}
C {lab_pin.sym} -2150 2780 0 0 {name=p281 sig_type=std_logic lab=B2_2
}
C {vsource.sym} -1560 2810 0 0 {name=V51 value="pwl(0n 1.8 1n 1.8 1.01n 0 2n 0 2.01n 1.8 3n 1.8 3.01n 0 4n 0 4.01n 1.8 5n 1.8 5.01n 0 6n 0 6.01n 1.8)" savecurrent=false
}
C {gnd.sym} -1560 2840 0 0 {name=l54 lab=GND
}
C {lab_pin.sym} -1560 2780 0 0 {name=p325 sig_type=std_logic lab=B2_3
}
C {vsource.sym} -3010 2920 0 0 {name=V52 value="pwl(0n 0 4n 0 4.01n 1.8 6n 1.8 6.01n 0)" savecurrent=false
}
C {gnd.sym} -3010 2950 0 0 {name=l52 lab=GND
}
C {lab_pin.sym} -3010 2890 0 0 {name=p326 sig_type=std_logic lab=B3_1
}
C {vsource.sym} -2720 2920 0 0 {name=V53 value="pwl(0n 0 4n 0 4.01n 1.8 6n 1.8 6.01n 0)" savecurrent=false
}
C {gnd.sym} -2720 2950 0 0 {name=l53 lab=GND
}
C {lab_pin.sym} -2720 2890 0 0 {name=p327 sig_type=std_logic lab=B3_2
}
C {vsource.sym} -2410 2930 0 0 {name=V54 value="pwl(0n 0 4n 0 4.01n 1.8 6n 1.8 6.01n 0)" savecurrent=false
}
C {gnd.sym} -2410 2960 0 0 {name=l55 lab=GND
}
C {lab_pin.sym} -2410 2900 0 0 {name=p328 sig_type=std_logic lab=B3_3
}
